<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>lte_hier_freq_estimate_cc</key>
<param><key>id</key><value>lte_hier_freq_estimate_cc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>lte_hier_pss_sync_cc</key>
<param><key>id</key><value>lte_hier_pss_sync_cc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>lte_cp_time_freq_sync_cc</key>
<param><key>id</key><value>lte_cp_time_freq_sync_cc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>lte_hier_sss_sync_cc</key>
<param><key>id</key><value>lte_hier_sss_sync_cc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>message</value></param>
</block>
<connection><source_block_id>lte_cp_time_freq_sync_cc_0</source_block_id><sink_block_id>lte_hier_pss_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_pss_sync_cc_0</source_block_id><sink_block_id>lte_hier_freq_estimate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_freq_estimate_cc_0</source_block_id><sink_block_id>lte_hier_sss_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>lte_cp_time_freq_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_sss_sync_cc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_sss_sync_cc_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>cell_id</source_key><sink_key>0</sink_key></connection>
</flow_graph>
