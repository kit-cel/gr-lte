<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>synchronization</value></param>
<param><key>title</key><value>LTE Synchronization</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>label</key><value>FFT Length</value></param>
<param><key>value</key><value>512</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>daemon</value></param>
<param><key>label</key><value>Daemon</value></param>
<param><key>value</key><value>daemon</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>lte_cp_time_freq_sync_cc</key>
<param><key>id</key><value>lte_cp_time_freq_sync_cc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>lte_pss_sync_hier_cc</key>
<param><key>id</key><value>lte_pss_sync_hier_cc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>lte_hier_freq_estimate_cc</key>
<param><key>id</key><value>lte_hier_freq_estimate_cc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>lte_hier_sss_sync_cc</key>
<param><key>id</key><value>lte_hier_sss_sync_cc_0</value></param>
<param><key>daemon</key><value>daemon</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<connection><source_block_id>lte_pss_sync_hier_cc_0</source_block_id><sink_block_id>lte_hier_freq_estimate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_freq_estimate_cc_0</source_block_id><sink_block_id>lte_hier_sss_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_sss_sync_cc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>lte_cp_time_freq_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_cp_time_freq_sync_cc_0</source_block_id><sink_block_id>lte_pss_sync_hier_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
