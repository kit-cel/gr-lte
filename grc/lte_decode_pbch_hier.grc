<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pbch_demod_hier</value></param>
<param><key>title</key><value>Decode PBCH hier</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>description</key><value>contains blocks for PBCH decoding</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<block>
<key>lte_qpsk_soft_demod_vcvf</key>
<param><key>id</key><value>lte_qpsk_soft_demod_vcvf_0</value></param>
</block>
<block>
<key>lte_descrambling_vfvf</key>
<param><key>id</key><value>descr</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>120</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>cell_id</value></param>
<param><key>label</key><value>cell_id</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>style</value></param>
<param><key>value</key><value>"tx_diversity"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vlen</value></param>
<param><key>value</key><value>240</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>z_in0</value></param>
<param><key>label</key><value>in0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>z_in1</value></param>
<param><key>label</key><value>in1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>z_in2</value></param>
<param><key>label</key><value>in2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>lte_pre_decoder_vcvc</key>
<param><key>id</key><value>lte_pre_decoder_vcvc_ant_2</value></param>
<param><key>N_ant</key><value>2</value></param>
<param><key>vlen</key><value>vlen</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_pre_decoder_vcvc</key>
<param><key>id</key><value>lte_pre_decoder_vcvc_ant_1</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>vlen</key><value>vlen</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_layer_demapper_vcvc</key>
<param><key>id</key><value>lte_layer_demapper_vcvc_0</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>vlen</key><value>vlen</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_layer_demapper_vcvc</key>
<param><key>id</key><value>lte_layer_demapper_vcvc_0_0</value></param>
<param><key>N_ant</key><value>2</value></param>
<param><key>vlen</key><value>vlen</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<connection><source_block_id>z_in0</source_block_id><sink_block_id>lte_pre_decoder_vcvc_ant_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>z_in0</source_block_id><sink_block_id>lte_pre_decoder_vcvc_ant_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>z_in1</source_block_id><sink_block_id>lte_pre_decoder_vcvc_ant_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>z_in1</source_block_id><sink_block_id>lte_pre_decoder_vcvc_ant_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>z_in2</source_block_id><sink_block_id>lte_pre_decoder_vcvc_ant_2</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>lte_qpsk_soft_demod_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_qpsk_soft_demod_vcvf_0</source_block_id><sink_block_id>descr</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cell_id</source_block_id><sink_block_id>descr</sink_block_id><source_key>0</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>descr</source_block_id><sink_block_id>out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pre_decoder_vcvc_ant_2</source_block_id><sink_block_id>lte_layer_demapper_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pre_decoder_vcvc_ant_1</source_block_id><sink_block_id>lte_layer_demapper_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_layer_demapper_vcvc_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_layer_demapper_vcvc_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
