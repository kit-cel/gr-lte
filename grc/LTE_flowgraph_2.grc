<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>LTE_flowgraph</value></param>
<param><key>title</key><value>LTE flowgraph</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp_val</value></param>
<param><key>value</key><value>int(samp_rate/1e4)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>slotl/0.0005</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slotl</value></param>
<param><key>value</key><value>7*fftlen+6*cpl+cpl0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cpl0</value></param>
<param><key>value</key><value>160*fftlen/2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>style</value></param>
<param><key>value</key><value>"tx_diversity"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cpl</value></param>
<param><key>value</key><value>144*fftlen/2048</value></param>
</block>
<block>
<key>lte_hier_pss_sync_cc</key>
<param><key>id</key><value>lte_hier_pss_sync_cc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>lte_hier_freq_estimate_cc</key>
<param><key>id</key><value>lte_hier_freq_estimate_cc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>lte_cp_time_freq_sync_cc</key>
<param><key>id</key><value>lte_cp_time_freq_sync_cc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>lte_remove_cp2_cvc</key>
<param><key>id</key><value>lte_remove_cp2_cvc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>lte_hier_sss_sync2_vcvc</key>
<param><key>id</key><value>lte_hier_sss_sync2_vcvc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
<param><key>daemon</key><value>daemon</value></param>
</block>
<block>
<key>lte_pre_decoder_vcvc</key>
<param><key>id</key><value>lte_pre_decoder_vcvc_0</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_layer_demapper_vcvc</key>
<param><key>id</key><value>lte_layer_demapper_vcvc_0_0</value></param>
<param><key>N_ant</key><value>2</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_layer_demapper_vcvc</key>
<param><key>id</key><value>lte_layer_demapper_vcvc_0</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_pre_decoder_vcvc</key>
<param><key>id</key><value>lte_pre_decoder_vcvc_0_0</value></param>
<param><key>N_ant</key><value>2</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_qpsk_soft_demod_vcvf</key>
<param><key>id</key><value>lte_qpsk_soft_demod_vcvf_0</value></param>
</block>
<block>
<key>lte_mib_unpack_vb</key>
<param><key>id</key><value>lte_mib_unpack_vb_0</value></param>
</block>
<block>
<key>lte_rate_unmatch_vff</key>
<param><key>id</key><value>lte_rate_unmatch_vff_0</value></param>
</block>
<block>
<key>lte_viterbi_vfvb</key>
<param><key>id</key><value>lte_viterbi_vfvb_0</value></param>
</block>
<block>
<key>lte_crc_calculator_vbvb</key>
<param><key>id</key><value>lte_crc_calculator_vbvb_0</value></param>
</block>
<block>
<key>gr_interleave</key>
<param><key>id</key><value>gr_interleave_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>vlen</key><value>240</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fftlen</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(fftlen)</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/demel/Dokumente/Messungen/Messung_LTE_2012-05-23_12:47:32.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0_0</value></param>
<param><key>file</key><value>/home/demel/gr-lte/data/Messung_Resampled_3072MSps.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1000</value></param>
<param><key>interp</key><value>interp_val</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>lte_extract_occupied_tones_vcvc</key>
<param><key>id</key><value>lte_extract_occupied_tones_vcvc_0</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl</value></param>
</block>
<block>
<key>lte_linear_OFDM_estimator_hier_vcvc</key>
<param><key>id</key><value>eq</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl</value></param>
</block>
<block>
<key>lte_channel_estimator</key>
<param><key>id</key><value>channel_est</value></param>
<param><key>N_rb_dl</key><value>6</value></param>
</block>
<block>
<key>lte_pbch_demux_vcvc</key>
<param><key>id</key><value>demux</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_cell_id_daemon</key>
<param><key>id</key><value>daemon</value></param>
<param><key>eq</key><value>"eq"</value></param>
<param><key>demux</key><value>"demux"</value></param>
<param><key>descr</key><value>"descr"</value></param>
</block>
<block>
<key>lte_descrambling_vfvf</key>
<param><key>id</key><value>descr</value></param>
</block>
<connection><source_block_id>lte_cp_time_freq_sync_cc_0</source_block_id><sink_block_id>lte_hier_pss_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_pss_sync_cc_0</source_block_id><sink_block_id>lte_hier_freq_estimate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_freq_estimate_cc_0</source_block_id><sink_block_id>lte_remove_cp2_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_remove_cp2_cvc_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>lte_hier_sss_sync2_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_sss_sync2_vcvc_0</source_block_id><sink_block_id>lte_extract_occupied_tones_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_extract_occupied_tones_vcvc_0</source_block_id><sink_block_id>eq</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pre_decoder_vcvc_0</source_block_id><sink_block_id>lte_layer_demapper_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pre_decoder_vcvc_0_0</source_block_id><sink_block_id>lte_layer_demapper_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_layer_demapper_vcvc_0_0</source_block_id><sink_block_id>gr_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>demux</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>demux</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>demux</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>demux</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>demux</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_qpsk_soft_demod_vcvf_0</source_block_id><sink_block_id>descr</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_interleave_0</source_block_id><sink_block_id>lte_qpsk_soft_demod_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_layer_demapper_vcvc_0</source_block_id><sink_block_id>gr_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>descr</source_block_id><sink_block_id>lte_rate_unmatch_vff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_crc_calculator_vbvb_0</source_block_id><sink_block_id>lte_mib_unpack_vb_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_crc_calculator_vbvb_0</source_block_id><sink_block_id>lte_mib_unpack_vb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_viterbi_vfvb_0</source_block_id><sink_block_id>lte_crc_calculator_vbvb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_rate_unmatch_vff_0</source_block_id><sink_block_id>lte_viterbi_vfvb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>lte_cp_time_freq_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_file_source_0_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_extract_occupied_tones_vcvc_0</source_block_id><sink_block_id>channel_est</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_est</source_block_id><sink_block_id>demux</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_est</source_block_id><sink_block_id>demux</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>channel_est</source_block_id><sink_block_id>demux</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>eq</source_block_id><sink_block_id>gr_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eq</source_block_id><sink_block_id>gr_null_sink_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eq</source_block_id><sink_block_id>gr_null_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>daemon</source_block_id><sink_block_id>channel_est</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>daemon</source_block_id><sink_block_id>demux</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>daemon</source_block_id><sink_block_id>descr</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
