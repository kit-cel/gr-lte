<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>decode_x</value></param>
<param><key>title</key><value>Decode X</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*rb*6</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1</value></param>
<param><key>label</key><value>out2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*rb*6</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_1</value></param>
<param><key>label</key><value>in2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*rb*6</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>in1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*rb*6</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*rb*6</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>label</key><value>out1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*rb*6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rb</value></param>
<param><key>label</key><value>Resource blocks</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<connection><source_block_id>pad_source_0_1</source_block_id><sink_block_id>pad_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
