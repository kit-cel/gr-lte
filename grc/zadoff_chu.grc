<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>zadoff_chu</value></param>
<param><key>title</key><value>Zadoff Chu Sequence Correlator</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length</value></param>
<param><key>value</key><value>63</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>init_val</value></param>
<param><key>value</key><value>29</value></param>
</block>
<block>
<key>lte_zadoff_chu_seq_generator_vc</key>
<param><key>id</key><value>lte_zadoff_chu_seq_generator_vc_0</value></param>
<param><key>len</key><value>length</value></param>
<param><key>init_val</key><value>init_val</value></param>
</block>
<block>
<key>gr_head</key>
<param><key>id</key><value>gr_head_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1</value></param>
<param><key>vlen</key><value>length</value></param>
</block>
<block>
<key>gr_vector_sink_x</key>
<param><key>id</key><value>gr_vector_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>length</value></param>
</block>
<connection><source_block_id>lte_zadoff_chu_seq_generator_vc_0</source_block_id><sink_block_id>gr_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_head_0</source_block_id><sink_block_id>gr_vector_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
