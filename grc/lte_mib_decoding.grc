<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>lte_crc_calculator_vbvb</key>
<param><key>id</key><value>lte_crc_calculator_vbvb_0</value></param>
</block>
<block>
<key>lte_mib_unpack_vb</key>
<param><key>id</key><value>lte_mib_unpack_vb_0</value></param>
</block>
<block>
<key>lte_viterbi_vfvb</key>
<param><key>id</key><value>lte_viterbi_vfvb_0</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>120</value></param>
</block>
<block>
<key>lte_rate_unmatch_vff</key>
<param><key>id</key><value>lte_rate_unmatch_vff_0</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>lte_mib_decoding</value></param>
<param><key>title</key><value>BCH MIB Decoding</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<connection><source_block_id>lte_crc_calculator_vbvb_0</source_block_id><sink_block_id>lte_mib_unpack_vb_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_crc_calculator_vbvb_0</source_block_id><sink_block_id>lte_mib_unpack_vb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_viterbi_vfvb_0</source_block_id><sink_block_id>lte_crc_calculator_vbvb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_rate_unmatch_vff_0</source_block_id><sink_block_id>lte_viterbi_vfvb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>in</source_block_id><sink_block_id>lte_rate_unmatch_vff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
