<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>PSS_Sync</value></param>
<param><key>title</key><value>PSS Synchronization</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fftl</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(fftl)</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>lte_extract_occupied_tones_vcvc</key>
<param><key>id</key><value>lte_extract_occupied_tones_vcvc_0</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>fftl</key><value>fftl</value></param>
</block>
<block>
<key>lte_pss_selector_cvc</key>
<param><key>id</key><value>pss_sel</value></param>
<param><key>fftl</key><value>fftl</value></param>
</block>
<block>
<key>lte_pss_calc_vc</key>
<param><key>id</key><value>lte_pss_calc_vc_0</value></param>
<param><key>fftl</key><value>fftl</value></param>
<param><key>tag</key><value>pss_tag</value></param>
<param><key>sel</key><value>pss_sel</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftl</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>lte_pss_tagging_cc</key>
<param><key>id</key><value>pss_tag</value></param>
<param><key>fftl</key><value>fftl</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>lte_extract_occupied_tones_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pss_sel</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_extract_occupied_tones_vcvc_0</source_block_id><sink_block_id>lte_pss_calc_vc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>in</source_block_id><sink_block_id>pss_sel</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>in</source_block_id><sink_block_id>pss_tag</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pss_tag</source_block_id><sink_block_id>out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
