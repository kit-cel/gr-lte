<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_pbch_extraction</value></param>
<param><key>title</key><value>PBCH Decoding</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>in2</value></param>
<param><key>label</key><value>in2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>in1</value></param>
<param><key>label</key><value>in1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>label</key><value>resource blocks</value></param>
<param><key>value</key><value>6</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>style</value></param>
<param><key>label</key><value>style</value></param>
<param><key>value</key><value>tx_diversity</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>in0</value></param>
<param><key>label</key><value>in0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl</value></param>
</block>
<block>
<key>gr_message_sink</key>
<param><key>id</key><value>gr_message_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dont_block</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>lte_pbch_demux_vcvc</key>
<param><key>id</key><value>demux</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_descrambling_vfvf</key>
<param><key>id</key><value>descr</value></param>
</block>
<block>
<key>lte_qpsk_soft_demod_vcvf</key>
<param><key>id</key><value>lte_qpsk_soft_demod_vcvf_0</value></param>
</block>
<block>
<key>gr_interleave</key>
<param><key>id</key><value>gr_interleave_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>vlen</key><value>240</value></param>
</block>
<block>
<key>lte_layer_demapper_vcvc</key>
<param><key>id</key><value>lte_layer_demapper_vcvc_0</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_pre_decoder_vcvc</key>
<param><key>id</key><value>lte_pre_decoder_vcvc_0_0</value></param>
<param><key>N_ant</key><value>2</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_layer_demapper_vcvc</key>
<param><key>id</key><value>lte_layer_demapper_vcvc_0_0</value></param>
<param><key>N_ant</key><value>2</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_pre_decoder_vcvc</key>
<param><key>id</key><value>lte_pre_decoder_vcvc_0</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>120</value></param>
</block>
<connection><source_block_id>in0</source_block_id><sink_block_id>demux</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>in1</source_block_id><sink_block_id>demux</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>in2</source_block_id><sink_block_id>demux</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>demux</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>demux</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>demux</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>demux</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>demux</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>descr</source_block_id><sink_block_id>out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_message_sink_0</source_block_id><sink_block_id>descr</sink_block_id><source_key>msg</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_interleave_0</source_block_id><sink_block_id>lte_qpsk_soft_demod_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_qpsk_soft_demod_vcvf_0</source_block_id><sink_block_id>descr</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_layer_demapper_vcvc_0_0</source_block_id><sink_block_id>gr_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_layer_demapper_vcvc_0</source_block_id><sink_block_id>gr_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pre_decoder_vcvc_0_0</source_block_id><sink_block_id>lte_layer_demapper_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pre_decoder_vcvc_0</source_block_id><sink_block_id>lte_layer_demapper_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
