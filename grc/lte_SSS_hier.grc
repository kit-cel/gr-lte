<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_sss_sync</value></param>
<param><key>title</key><value>SSS Synchronization Block</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftl</value></param>
<param><key>label</key><value>FFT Length</value></param>
<param><key>value</key><value>512</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>lte_sss_tagging_cc</key>
<param><key>id</key><value>tag</value></param>
<param><key>fftl</key><value>fftl</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>lte_extract_occupied_tones_vcvc</key>
<param><key>id</key><value>lte_extract_occupied_tones_vcvc_0</value></param>
<param><key>N_rb_dl</key><value>6</value></param>
<param><key>fftl</key><value>fftl</value></param>
</block>
<block>
<key>lte_sss_calc_vci</key>
<param><key>id</key><value>lte_sss_calc_vci_0</value></param>
<param><key>fftl</key><value>fftl</value></param>
<param><key>tag</key><value>tag</value></param>
<param><key>daemon</key><value>daemon</value></param>
</block>
<block>
<key>lte_sss_selector_cvc</key>
<param><key>id</key><value>lte_sss_selector_cvc_0</value></param>
<param><key>fftl</key><value>fftl</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fftl</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(fftl)</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>lte_cell_id_daemon</key>
<param><key>id</key><value>lte_cell_id_daemon_0</value></param>
<param><key>eq</key><value>eq</value></param>
<param><key>demux</key><value>demux</value></param>
<param><key>descr</key><value>descr</value></param>
</block>
<connection><source_block_id>in</source_block_id><sink_block_id>tag</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tag</source_block_id><sink_block_id>out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_extract_occupied_tones_vcvc_0</source_block_id><sink_block_id>lte_sss_calc_vci_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_sss_selector_cvc_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>lte_extract_occupied_tones_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>in</source_block_id><sink_block_id>lte_sss_selector_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
