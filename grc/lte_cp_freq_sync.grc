<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_cp_freq_sync</value></param>
<param><key>title</key><value>CP Frequency Synchronization</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cpl</value></param>
<param><key>value</key><value>144*fftl/2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cpl0</value></param>
<param><key>value</key><value>160*fftl/2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slotl</value></param>
<param><key>value</key><value>7*fftl+6*cpl+cpl0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>slotl/0.0005</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftl</value></param>
<param><key>label</key><value>FFT Length</value></param>
<param><key>value</key><value>512</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>sig</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>gr.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>lte_freq_estimate_c</key>
<param><key>id</key><value>lte_freq_estimate_c_0</value></param>
<param><key>fftl</key><value>fftl</value></param>
<param><key>sig</key><value>sig</value></param>
</block>
<connection><source_block_id>sig</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_0</source_block_id><sink_block_id>lte_freq_estimate_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>in</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_0</source_block_id><sink_block_id>out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
