<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>demod_and_eq</value></param>
<param><key>title</key><value>OFDM Operations</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>label</key><value>FFT Length</value></param>
<param><key>value</key><value>512</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>label</key><value>resource blocks</value></param>
<param><key>value</key><value>6</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>lte_extract_occupied_tones_vcvc</key>
<param><key>id</key><value>lte_extract_occupied_tones_vcvc_0</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>lte_linear_OFDM_equalizer_hier_vcvc</key>
<param><key>id</key><value>eq</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_remove_cp_cvc</key>
<param><key>id</key><value>lte_remove_cp_cvc_1</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fftlen</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(fftlen)</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out0</value></param>
<param><key>label</key><value>out0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out1</value></param>
<param><key>label</key><value>out1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out2</value></param>
<param><key>label</key><value>out2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>lte_extract_occupied_tones_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_extract_occupied_tones_vcvc_0</source_block_id><sink_block_id>eq</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_remove_cp_cvc_1</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>lte_remove_cp_cvc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eq</source_block_id><sink_block_id>out1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eq</source_block_id><sink_block_id>out2</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eq</source_block_id><sink_block_id>out0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
