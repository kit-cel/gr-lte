<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_decode_bch_hier</value></param>
<param><key>title</key><value>Decode BCH hier</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>description</key><value>contains blocks for BCH decoding</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<block>
<key>lte_rate_unmatch_vff</key>
<param><key>id</key><value>lte_rate_unmatch_vff_0_0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out0</value></param>
<param><key>label</key><value>mib</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>24</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>out1</value></param>
<param><key>label</key><value>N_ant</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>120</value></param>
</block>
<block>
<key>lte_crc_calculator_vbvb</key>
<param><key>id</key><value>lte_crc_calculator_vbvb_0_0</value></param>
</block>
<block>
<key>lte_viterbi_vfvb</key>
<param><key>id</key><value>lte_viterbi_vfvb_0_0</value></param>
</block>
<connection><source_block_id>lte_viterbi_vfvb_0_0</source_block_id><sink_block_id>lte_crc_calculator_vbvb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_rate_unmatch_vff_0_0</source_block_id><sink_block_id>lte_viterbi_vfvb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>in</source_block_id><sink_block_id>lte_rate_unmatch_vff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_crc_calculator_vbvb_0_0</source_block_id><sink_block_id>out0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_crc_calculator_vbvb_0_0</source_block_id><sink_block_id>out1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
