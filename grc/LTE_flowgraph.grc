<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>LTE_flowgraph</value></param>
<param><key>title</key><value>LTE flowgraph</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>style</value></param>
<param><key>value</key><value>"tx_diversity"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp_val</value></param>
<param><key>value</key><value>int(samp_rate/1e4)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cpl</value></param>
<param><key>value</key><value>144*fft_len/2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cpl0</value></param>
<param><key>value</key><value>160*fft_len/2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slotl</value></param>
<param><key>value</key><value>7*fft_len+6*cpl+cpl0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(slotl/0.0005)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tag_key</value></param>
<param><key>value</key><value>"symbol"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>msg_buf_name</value></param>
<param><key>value</key><value>"cell_id"</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1</value></param>
<param><key>file</key><value>/home/johannes/src/gr-lte/data/Messung_LTE_2012-05-23_12:47:32.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/demel/gr-lte/data/Messung_Resampled_3072MSps.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/johannes/gr-lte/data/Resampled_LTE_2012_47:32.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1000</value></param>
<param><key>interp</key><value>interp_val</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>lte_hier_pss_sync_cc</key>
<param><key>id</key><value>lte_hier_pss_sync_cc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>lte_hier_freq_estimate_cc</key>
<param><key>id</key><value>lte_hier_freq_estimate_cc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>lte_cp_time_freq_sync_cc</key>
<param><key>id</key><value>lte_cp_time_freq_sync_cc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>decode_x</key>
<param><key>id</key><value>decode_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>rb</key><value>N_rb_dl</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl</value></param>
</block>
<block>
<key>lte_decode_pbch_vcvf</key>
<param><key>id</key><value>lte_decode_pbch_vcvf_0</value></param>
</block>
<block>
<key>lte_remove_cp_cvc</key>
<param><key>id</key><value>lte_remove_cp_cvc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
<param><key>tag_key</key><value>tag_key</value></param>
</block>
<block>
<key>lte_hier_sss_sync_cc</key>
<param><key>id</key><value>lte_hier_sss_sync_cc_1</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>lte_decode_bch_vfvb</key>
<param><key>id</key><value>lte_decode_bch_vfvb_0</value></param>
</block>
<block>
<key>lte_mib_unpack_vb</key>
<param><key>id</key><value>lte_mib_unpack_vb_0</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(fft_len)</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>lte_channel_estimator</key>
<param><key>id</key><value>lte_channel_estimator_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>tag_key</key><value>tag_key</value></param>
</block>
<block>
<key>lte_extract_occupied_tones_vcvc</key>
<param><key>id</key><value>lte_extract_occupied_tones_vcvc_0</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>lte_pbch_demux_vcvc</key>
<param><key>id</key><value>lte_pbch_demux_vcvc_1</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_channel_estimator_vcvc</key>
<param><key>id</key><value>lte_channel_estimator_vcvc_0_0</value></param>
<param><key>subcarriers</key><value>12*N_rb_dl</value></param>
<param><key>tag_key</key><value>tag_key</value></param>
<param><key>msg_buf_name</key><value>msg_buf_name</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers_p1</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
</block>
<block>
<key>lte_channel_estimator_vcvc</key>
<param><key>id</key><value>lte_channel_estimator_vcvc_0</value></param>
<param><key>subcarriers</key><value>12*N_rb_dl</value></param>
<param><key>tag_key</key><value>tag_key</value></param>
<param><key>msg_buf_name</key><value>msg_buf_name</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers_p0</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_symbols</value></param>
<param><key>value</key><value>frame_pilots_0[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_carriers_p0</value></param>
<param><key>value</key><value>frame_pilots_0[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_carriers_p1</value></param>
<param><key>value</key><value>frame_pilots_1[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_pilots_0</value></param>
<param><key>value</key><value>lte.frame_pilot_value_and_position(N_rb_dl, 124, 1, 0)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>lte</value></param>
<param><key>import</key><value>import lte</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_pilots_1</value></param>
<param><key>value</key><value>lte.frame_pilot_value_and_position(N_rb_dl, 124, 1, 1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>value</key><value>15</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_1</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_cp_time_freq_sync_cc_0</source_block_id><sink_block_id>lte_hier_pss_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_pss_sync_cc_0</source_block_id><sink_block_id>lte_hier_freq_estimate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>lte_cp_time_freq_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decode_x_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decode_x_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decode_x_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_0</source_block_id><sink_block_id>decode_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_0</source_block_id><sink_block_id>decode_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_0</source_block_id><sink_block_id>decode_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_sss_sync_cc_1</source_block_id><sink_block_id>lte_pbch_demux_vcvc_1</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_0</source_block_id><sink_block_id>lte_pbch_demux_vcvc_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_0</source_block_id><sink_block_id>lte_pbch_demux_vcvc_1</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lte_hier_sss_sync_cc_1</source_block_id><sink_block_id>lte_remove_cp_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_remove_cp_cvc_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_extract_occupied_tones_vcvc_0</source_block_id><sink_block_id>lte_channel_estimator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_sss_sync_cc_1</source_block_id><sink_block_id>lte_channel_estimator_0</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>lte_hier_sss_sync_cc_1</source_block_id><sink_block_id>lte_decode_pbch_vcvf_0</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>lte_pbch_demux_vcvc_1</source_block_id><sink_block_id>lte_decode_pbch_vcvf_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lte_pbch_demux_vcvc_1</source_block_id><sink_block_id>lte_decode_pbch_vcvf_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_pbch_demux_vcvc_1</source_block_id><sink_block_id>lte_decode_pbch_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_decode_pbch_vcvf_0</source_block_id><sink_block_id>lte_decode_bch_vfvb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_decode_bch_vfvb_0</source_block_id><sink_block_id>lte_mib_unpack_vb_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_decode_bch_vfvb_0</source_block_id><sink_block_id>lte_mib_unpack_vb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_freq_estimate_cc_0</source_block_id><sink_block_id>lte_hier_sss_sync_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>lte_extract_occupied_tones_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_0</source_block_id><sink_block_id>lte_pbch_demux_vcvc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_extract_occupied_tones_vcvc_0</source_block_id><sink_block_id>lte_pbch_demux_vcvc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_extract_occupied_tones_vcvc_0</source_block_id><sink_block_id>lte_channel_estimator_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_extract_occupied_tones_vcvc_0</source_block_id><sink_block_id>lte_channel_estimator_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_vcvc_0_0</source_block_id><sink_block_id>lte_pbch_demux_vcvc_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_vcvc_0</source_block_id><sink_block_id>lte_pbch_demux_vcvc_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
