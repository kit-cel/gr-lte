<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>LTE_flowgraph</value></param>
<param><key>title</key><value>LTE flowgraph</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>style</value></param>
<param><key>value</key><value>"tx_diversity"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp_val</value></param>
<param><key>value</key><value>int(samp_rate/1e4)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cpl</value></param>
<param><key>value</key><value>144*fft_len/2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cpl0</value></param>
<param><key>value</key><value>160*fft_len/2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slotl</value></param>
<param><key>value</key><value>7*fft_len+6*cpl+cpl0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(slotl/0.0005)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tag_key</value></param>
<param><key>value</key><value>"symbol"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>msg_buf_name</value></param>
<param><key>value</key><value>"cell_id"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>lte_source_c</key>
<param><key>id</key><value>lte_source_c_0</value></param>
<param><key>samp_rate</key><value>30.72e6</value></param>
</block>
<block>
<key>lte_cp_time_freq_sync_cc</key>
<param><key>id</key><value>lte_cp_time_freq_sync_cc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>lte_channel_est_hier</key>
<param><key>id</key><value>lte_channel_est_hier_0</value></param>
<param><key>N_rb_dl</key><value>6</value></param>
<param><key>tag_key</key><value>tag_key</value></param>
</block>
<block>
<key>lte_extract_occupied_tones_vcvc</key>
<param><key>id</key><value>lte_extract_occupied_tones_vcvc_0</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(fft_len)</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>lte_remove_cp_cvc</key>
<param><key>id</key><value>lte_remove_cp_cvc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
<param><key>tag_key</key><value>tag_key</value></param>
</block>
<block>
<key>lte_hier_freq_estimate_cc</key>
<param><key>id</key><value>lte_hier_freq_estimate_cc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>lte_hier_pss_sync_cc</key>
<param><key>id</key><value>lte_hier_pss_sync_cc_0</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>lte_hier_sss_sync_cc</key>
<param><key>id</key><value>lte_hier_sss_sync_cc_1</value></param>
<param><key>fftl</key><value>fft_len</value></param>
</block>
<block>
<key>lte_pbch_demux_vcvc</key>
<param><key>id</key><value>lte_pbch_demux_vcvc_1</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_decode_pbch_vcvf</key>
<param><key>id</key><value>lte_decode_pbch_vcvf_0</value></param>
</block>
<block>
<key>lte_decode_bch_hier</key>
<param><key>id</key><value>lte_decode_bch_hier_0</value></param>
</block>
<block>
<key>lte_mib_unpack_vb</key>
<param><key>id</key><value>lte_mib_unpack_vb_0</value></param>
</block>
<connection><source_block_id>lte_source_c_0</source_block_id><sink_block_id>lte_cp_time_freq_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_sss_sync_cc_1</source_block_id><sink_block_id>lte_channel_est_hier_0</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>lte_channel_est_hier_0</source_block_id><sink_block_id>lte_pbch_demux_vcvc_1</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lte_channel_est_hier_0</source_block_id><sink_block_id>lte_pbch_demux_vcvc_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_extract_occupied_tones_vcvc_0</source_block_id><sink_block_id>lte_pbch_demux_vcvc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_extract_occupied_tones_vcvc_0</source_block_id><sink_block_id>lte_channel_est_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_sss_sync_cc_1</source_block_id><sink_block_id>lte_pbch_demux_vcvc_1</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>lte_extract_occupied_tones_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_freq_estimate_cc_0</source_block_id><sink_block_id>lte_hier_sss_sync_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pbch_demux_vcvc_1</source_block_id><sink_block_id>lte_decode_pbch_vcvf_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_pbch_demux_vcvc_1</source_block_id><sink_block_id>lte_decode_pbch_vcvf_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lte_hier_sss_sync_cc_1</source_block_id><sink_block_id>lte_decode_pbch_vcvf_0</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>lte_remove_cp_cvc_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_sss_sync_cc_1</source_block_id><sink_block_id>lte_remove_cp_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_hier_pss_sync_cc_0</source_block_id><sink_block_id>lte_hier_freq_estimate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_cp_time_freq_sync_cc_0</source_block_id><sink_block_id>lte_hier_pss_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pbch_demux_vcvc_1</source_block_id><sink_block_id>lte_decode_pbch_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_decode_pbch_vcvf_0</source_block_id><sink_block_id>lte_decode_bch_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_decode_bch_hier_0</source_block_id><sink_block_id>lte_mib_unpack_vb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_decode_bch_hier_0</source_block_id><sink_block_id>lte_mib_unpack_vb_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
