<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_hier_flowgraph</value></param>
<param><key>title</key><value>LTE hierarchical Flowgraph</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>description</key><value>LTE Flowgraph grouped into hierarchical Blocks</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>7.68e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>style</value></param>
<param><key>value</key><value>"tx_diversity"</value></param>
</block>
<block>
<key>lte_cell_id_daemon</key>
<param><key>id</key><value>daemon</value></param>
<param><key>eq</key><value>"eq.eq"</value></param>
<param><key>demux</key><value>"ext.demux"</value></param>
<param><key>descr</key><value>"ext.descr"</value></param>
</block>
<block>
<key>synchronization</key>
<param><key>id</key><value>synchronization_0</value></param>
<param><key>fftlen</key><value>512</value></param>
<param><key>daemon</key><value>"daemon"</value></param>
</block>
<block>
<key>lte_pbch_extraction</key>
<param><key>id</key><value>ext</value></param>
<param><key>N_rb_dl</key><value>6</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_bch_decode</key>
<param><key>id</key><value>lte_bch_decode_0</value></param>
</block>
<block>
<key>lte_mib_unpack_vb</key>
<param><key>id</key><value>lte_mib_unpack_vb_0</value></param>
</block>
<block>
<key>demod_and_eq</key>
<param><key>id</key><value>eq</value></param>
<param><key>fftlen</key><value>512</value></param>
<param><key>N_rb_dl</key><value>6</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>file</key><value>/home/demel/Dokumente/Messungen/Messung_LTE_2012-05-23_12:47:32.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1000</value></param>
<param><key>interp</key><value>768</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<connection><source_block_id>eq</source_block_id><sink_block_id>ext</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>eq</source_block_id><sink_block_id>ext</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>eq</source_block_id><sink_block_id>ext</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>synchronization_0</source_block_id><sink_block_id>eq</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ext</source_block_id><sink_block_id>lte_bch_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_bch_decode_0</source_block_id><sink_block_id>lte_mib_unpack_vb_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_bch_decode_0</source_block_id><sink_block_id>lte_mib_unpack_vb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>synchronization_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
