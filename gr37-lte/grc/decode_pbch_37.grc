<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>style</value></param>
<param><key>value</key><value>"tx_diversity"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vlen</value></param>
<param><key>value</key><value>240</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pbch_descr_key</value></param>
<param><key>value</key><value>"descr_part"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>label</key><value>resource blocks</value></param>
<param><key>value</key><value>50</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>pbch_descrambler_37</key>
<param><key>id</key><value>pbch_descrambler_37_0</value></param>
</block>
<block>
<key>lte_pbch_demux_vcvc</key>
<param><key>id</key><value>lte_pbch_demux_vcvc_0</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_qpsk_soft_demod_vcvf</key>
<param><key>id</key><value>lte_qpsk_soft_demod_vcvf_0</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>lte_pre_decoder_vcvc</key>
<param><key>id</key><value>lte_pre_decoder_vcvc_0</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>vlen</key><value>vlen</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_layer_demapper_vcvc</key>
<param><key>id</key><value>lte_layer_demapper_vcvc_0</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>vlen</key><value>vlen</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_pre_decoder_vcvc</key>
<param><key>id</key><value>lte_pre_decoder_vcvc_0_0</value></param>
<param><key>N_ant</key><value>2</value></param>
<param><key>vlen</key><value>vlen</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_layer_demapper_vcvc</key>
<param><key>id</key><value>lte_layer_demapper_vcvc_0_0</value></param>
<param><key>N_ant</key><value>2</value></param>
<param><key>vlen</key><value>vlen</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>120</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>decode_pbch</value></param>
<param><key>title</key><value>Decode PBCH 3.7</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>description</key><value>hier block which sums up all operations to decode pbch</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<block>
<key>lte_pbch_demux_vcvc</key>
<param><key>id</key><value>lte_pbch_demux_vcvc_0_0</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_pbch_demux_vcvc</key>
<param><key>id</key><value>lte_pbch_demux_vcvc_0_1</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_2</value></param>
<param><key>label</key><value>in2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_99</value></param>
<param><key>label</key><value>cell_id</value></param>
<param><key>type</key><value>message</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>lte_pbch_demux_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_99</source_block_id><sink_block_id>lte_pbch_demux_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>pad_source_99</source_block_id><sink_block_id>lte_pbch_demux_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>pad_source_99</source_block_id><sink_block_id>lte_pbch_demux_vcvc_0_1</sink_block_id><source_key>0</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>pbch_descrambler_37_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_99</source_block_id><sink_block_id>pbch_descrambler_37_0</sink_block_id><source_key>0</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>lte_qpsk_soft_demod_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_qpsk_soft_demod_vcvf_0</source_block_id><sink_block_id>pbch_descrambler_37_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pbch_demux_vcvc_0</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pre_decoder_vcvc_0</source_block_id><sink_block_id>lte_layer_demapper_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pbch_demux_vcvc_0_1</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lte_pbch_demux_vcvc_0_0</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_pbch_demux_vcvc_0_0</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_layer_demapper_vcvc_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_layer_demapper_vcvc_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_pre_decoder_vcvc_0_0</source_block_id><sink_block_id>lte_layer_demapper_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pbch_demux_vcvc_0</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>lte_pbch_demux_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>lte_pbch_demux_vcvc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
