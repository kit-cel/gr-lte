<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>title</key><value>LTE_test</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frames</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>30.72e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>poss1</value></param>
<param><key>value</key><value>mymap1[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mymap1</value></param>
<param><key>value</key><value>lte.frame_pilot_value_and_position(N_rb_dl, 124, 1, 0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mymap</value></param>
<param><key>value</key><value>lte.frame_pilot_value_and_position(N_rb_dl, 124, 1, 0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vals</value></param>
<param><key>value</key><value>mymap[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>poss0</value></param>
<param><key>value</key><value>mymap[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pbch_descr_key</value></param>
<param><key>value</key><value>"descr_part"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vlen</value></param>
<param><key>value</key><value>240</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>style</value></param>
<param><key>value</key><value>"tx_diversity"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp_val</value></param>
<param><key>value</key><value>int(samp_rate/1e4)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import lte</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>interp_val</value></param>
<param><key>decim</key><value>1000</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/johannes/recorded_data/Messung_LTE_2012-05-23_12:47:32.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>lte_channel_estimator_vcvc</key>
<param><key>id</key><value>lte_channel_estimator_vcvc_0_0</value></param>
<param><key>subcarriers</key><value>12*N_rb_dl</value></param>
<param><key>tag_key</key><value>symbol</value></param>
<param><key>pilot_carriers</key><value>poss1</value></param>
<param><key>pilot_symbols</key><value>vals</value></param>
</block>
<block>
<key>lte_channel_estimator_vcvc</key>
<param><key>id</key><value>lte_channel_estimator_vcvc_0</value></param>
<param><key>subcarriers</key><value>12*N_rb_dl</value></param>
<param><key>tag_key</key><value>symbol</value></param>
<param><key>pilot_carriers</key><value>poss0</value></param>
<param><key>pilot_symbols</key><value>vals</value></param>
</block>
<block>
<key>lte_mib_unpack_vbm</key>
<param><key>id</key><value>MIB</value></param>
</block>
<block>
<key>decode_bch_hier_gr37</key>
<param><key>id</key><value>decode_bch_hier_gr37_0</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>lte_remove_cp_cvc</key>
<param><key>id</key><value>lte_remove_cp_cvc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
<param><key>key</key><value>slot</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fftlen</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(fftlen)</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>lte_extract_subcarriers_vcvc</key>
<param><key>id</key><value>lte_extract_subcarriers_vcvc_0</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>lte_sss_calculator_vcm</key>
<param><key>id</key><value>lte_sss_calculator_vcm_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftlen</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor_performance</key>
<param><key>id</key><value>blocks_ctrlport_monitor_performance_0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>lte_rs_map_generator_m</key>
<param><key>id</key><value>lte_rs_map_generator_m_1</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>ant_port</key><value>0</value></param>
</block>
<block>
<key>lte_rs_map_generator_m</key>
<param><key>id</key><value>lte_rs_map_generator_m_0</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>ant_port</key><value>1</value></param>
</block>
<block>
<key>lte_sync_cc</key>
<param><key>id</key><value>lte_sync_cc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>decode_pbch</key>
<param><key>id</key><value>decode_pbch_0</value></param>
<param><key>N_rb_dl</key><value>50</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>[1] * (12 * N_rb_dl*140*frames)</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>12 * N_rb_dl</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>[1] * (12 * N_rb_dl*140*frames)</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>12 * N_rb_dl</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.from_long(124)</value></param>
<param><key>period</key><value>10</value></param>
</block>
<connection><source_block_id>lte_sync_cc_0</source_block_id><sink_block_id>lte_remove_cp_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_sync_cc_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>cell_id</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>lte_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>decode_pbch_0</sink_block_id><source_key>strobe</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>decode_bch_hier_gr37_0</source_block_id><sink_block_id>MIB</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decode_bch_hier_gr37_0</source_block_id><sink_block_id>MIB</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>decode_pbch_0</source_block_id><sink_block_id>decode_bch_hier_gr37_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>lte_rs_map_generator_m_1</sink_block_id><source_key>strobe</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_vcvc_0</source_block_id><sink_block_id>decode_pbch_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_vcvc_0_0</source_block_id><sink_block_id>decode_pbch_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lte_rs_map_generator_m_0</source_block_id><sink_block_id>lte_channel_estimator_vcvc_0_0</sink_block_id><source_key>pilots</source_key><sink_key>pilots</sink_key></connection>
<connection><source_block_id>lte_rs_map_generator_m_1</source_block_id><sink_block_id>lte_channel_estimator_vcvc_0</sink_block_id><source_key>pilots</source_key><sink_key>pilots</sink_key></connection>
<connection><source_block_id>lte_extract_subcarriers_vcvc_0</source_block_id><sink_block_id>decode_pbch_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_extract_subcarriers_vcvc_0</source_block_id><sink_block_id>lte_channel_estimator_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_extract_subcarriers_vcvc_0</source_block_id><sink_block_id>lte_channel_estimator_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_remove_cp_cvc_0</source_block_id><sink_block_id>blocks_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_sync_cc_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>lte_extract_subcarriers_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_remove_cp_cvc_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>lte_rs_map_generator_m_0</sink_block_id><source_key>strobe</source_key><sink_key>cell_id</sink_key></connection>
</flow_graph>
