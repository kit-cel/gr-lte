<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_top_block</value></param>
<param><key>title</key><value>LTE_test</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp_val</value></param>
<param><key>value</key><value>int(samp_rate/1e4)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>30.72e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pbch_descr_key</value></param>
<param><key>value</key><value>"descr_part"</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor_performance</key>
<param><key>id</key><value>blocks_ctrlport_monitor_performance_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>interp_val</value></param>
<param><key>decim</key><value>1000</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/johannes/recorded_data/Messung_LTE_2012-05-23_12:47:32.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>lte_ofdm_hier</key>
<param><key>id</key><value>lte_ofdm_hier_0</value></param>
<param><key>N_rb_dl</key><value>50</value></param>
<param><key>fftlen</key><value>2048</value></param>
<param><key>ofdm_key</key><value>"slot"</value></param>
</block>
<block>
<key>lte_pss_sync_37</key>
<param><key>id</key><value>lte_pss_sync_37_0</value></param>
<param><key>fftlen</key><value>fftlen</value></param>
</block>
<block>
<key>lte_cp_freq_sync</key>
<param><key>id</key><value>lte_cp_freq_sync_0</value></param>
<param><key>fftlen</key><value>2048</value></param>
</block>
<block>
<key>lte_rough_symbol_sync_cc</key>
<param><key>id</key><value>lte_rough_symbol_sync_cc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>lte_estimator_hier</key>
<param><key>id</key><value>lte_estimator_hier_0</value></param>
<param><key>initial_id</key><value>387</value></param>
<param><key>estimator_key</key><value>"slot"</value></param>
<param><key>N_rb_dl</key><value>50</value></param>
</block>
<block>
<key>decode_bch_hier_gr37</key>
<param><key>id</key><value>decode_bch_hier_gr37_0</value></param>
</block>
<block>
<key>decode_pbch_37</key>
<param><key>id</key><value>decode_pbch_37_0</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_mib_unpack_vbm</key>
<param><key>id</key><value>MIB</value></param>
</block>
<block>
<key>top_block</key>
<param><key>id</key><value>top_block_0</value></param>
<param><key>fftlen</key><value>fftlen</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>group_key</key><value>"N_id_2"</value></param>
<param><key>offset_key</key><value>"offset_marker"</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>16</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>n</key><value>10000</value></param>
<param><key>vlen</key><value>16</value></param>
</block>
<block>
<key>decode_pcfich_37</key>
<param><key>id</key><value>decode_pcfich_37_0</value></param>
<param><key>vlen</key><value>16</value></param>
</block>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>lte_rough_symbol_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>top_block_0</source_block_id><sink_block_id>lte_estimator_hier_0</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>decode_bch_hier_gr37_0</source_block_id><sink_block_id>MIB</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decode_bch_hier_gr37_0</source_block_id><sink_block_id>MIB</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_ofdm_hier_0</source_block_id><sink_block_id>lte_estimator_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>top_block_0</source_block_id><sink_block_id>lte_ofdm_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_rough_symbol_sync_cc_0</source_block_id><sink_block_id>lte_pss_sync_37_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pss_sync_37_0</source_block_id><sink_block_id>lte_cp_freq_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_cp_freq_sync_0</source_block_id><sink_block_id>top_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_estimator_hier_0</source_block_id><sink_block_id>decode_pbch_37_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_estimator_hier_0</source_block_id><sink_block_id>decode_pbch_37_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lte_ofdm_hier_0</source_block_id><sink_block_id>decode_pbch_37_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decode_pbch_37_0</source_block_id><sink_block_id>decode_bch_hier_gr37_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>top_block_0</source_block_id><sink_block_id>decode_pbch_37_0</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>MIB</source_block_id><sink_block_id>decode_pcfich_37_0</sink_block_id><source_key>N_ant</source_key><sink_key>N_ant</sink_key></connection>
<connection><source_block_id>top_block_0</source_block_id><sink_block_id>decode_pcfich_37_0</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>top_block_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>decode_pcfich_37_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>decode_pcfich_37_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>decode_pcfich_37_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
