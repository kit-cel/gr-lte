<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>vlen</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pbch_descr_key</value></param>
<param><key>value</key><value>"descr_part"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>style</value></param>
<param><key>value</key><value>"tx_diversity"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ants</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_2</value></param>
<param><key>label</key><value>in2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>lte_layer_demapper_vcvc</key>
<param><key>id</key><value>lte_layer_demapper_vcvc_0</value></param>
<param><key>N_ant</key><value>ants</value></param>
<param><key>vlen</key><value>vlen</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_pcfich_unpack_vfm</key>
<param><key>id</key><value>lte_pcfich_unpack_vfm_0</value></param>
<param><key>key</key><value>subframe</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>CFI</value></param>
<param><key>type</key><value>message</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>lte_pre_decoder_vcvc</key>
<param><key>id</key><value>lte_pre_decoder_vcvc_0</value></param>
<param><key>N_ant</key><value>ants</value></param>
<param><key>vlen</key><value>vlen</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_qpsk_soft_demod_vcvf</key>
<param><key>id</key><value>lte_qpsk_soft_demod_vcvf_0</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>decode_pcfich_37</value></param>
<param><key>title</key><value>Decode PCFICH</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>description</key><value>hier block combining blocks and parameters to decode PCFICH</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>lte_pre_decoder_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lte_layer_demapper_vcvc_0</source_block_id><sink_block_id>lte_qpsk_soft_demod_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pcfich_unpack_vfm_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>CFI</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_qpsk_soft_demod_vcvf_0</source_block_id><sink_block_id>lte_pcfich_unpack_vfm_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pre_decoder_vcvc_0</source_block_id><sink_block_id>lte_layer_demapper_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
