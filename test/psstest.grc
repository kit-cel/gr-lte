<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>title</key><value>lte_mimo_pss_sync</value></param>
<param><key>author</key><value>Kristian Maier</value></param>
<param><key>description</key><value>hier block for pss time sync</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_fftl_1024</value></param>
<param><key>value</key><value>[-0.00141422616403692464996655342446274517, 0.015642606095112098624211327546618122142, 0.030243226636871359258584845974837662652, 0.052594337944074170954067426464462187141, 0.078507642615830444676738864018261665478, 0.103921182343643836443192185470252297819, 0.124279358836934944454455376217083539814, 0.135614264806182049927230082175810821354, 0.135614264806182049927230082175810821354, 0.124279358836934944454455376217083539814, 0.103921182343643836443192185470252297819, 0.078507642615830444676738864018261665478, 0.052594337944074170954067426464462187141,0.030243226636871359258584845974837662652,0.015642606095112098624211327546618122142,-0.00141422616403692464996655342446274517]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>synclen</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>label</key><value>FFT length</value></param>
<param><key>value</key><value>1024</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>1e6</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>in1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>2</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/maier/gr-lte/test/lte5framesFadingChannelETU_vec2.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>2</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>lte_mimo_pss_coarse_sync</key>
<param><key>id</key><value>lte_mimo_pss_coarse_sync_0</value></param>
<param><key>syncl</key><value>synclen</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>fftlen/128</value></param>
<param><key>taps</key><value>taps_fftl_1024</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>fftlen/128</value></param>
<param><key>taps</key><value>taps_fftl_1024</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>400000</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>400000</value></param>
</block>
<block>
<key>lte_mimo_pss_fine_sync</key>
<param><key>id</key><value>lte_mimo_pss_fine_sync_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_head_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_head_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_vector_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>lte_mimo_pss_fine_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>lte_mimo_pss_fine_sync_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_fine_sync_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_fine_sync_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_coarse_sync_0</source_block_id><sink_block_id>lte_mimo_pss_fine_sync_0</sink_block_id><source_key>coarse_pos</source_key><sink_key>coarse_pos</sink_key></connection>
<connection><source_block_id>blocks_head_0_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_coarse_sync_0</source_block_id><sink_block_id>lte_mimo_pss_fine_sync_0</sink_block_id><source_key>N_id_2</source_key><sink_key>N_id_2</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>lte_mimo_pss_coarse_sync_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>lte_mimo_pss_coarse_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
