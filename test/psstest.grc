<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>title</key><value>lte_mimo_pss_sync</value></param>
<param><key>author</key><value>Kristian Maier</value></param>
<param><key>description</key><value>hier block for pss time sync</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>filter.optfir.low_pass(1, fftlen*15e3, 472.5e3, 960e3, 0.2, 20)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>synclen</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>label</key><value>FFT length</value></param>
<param><key>value</key><value>1024</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>1e6</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>in1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>2</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>lte_mimo_pss_coarse_control</key>
<param><key>id</key><value>lte_mimo_pss_coarse_control_0</value></param>
</block>
<block>
<key>lte_mimo_pss_tagger</key>
<param><key>id</key><value>lte_mimo_pss_tagger_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>lte_mimo_pss_coarse_sync</key>
<param><key>id</key><value>lte_mimo_pss_coarse_sync_0</value></param>
<param><key>syncl</key><value>synclen</value></param>
</block>
<block>
<key>lte_mimo_pss_fine_sync</key>
<param><key>id</key><value>lte_mimo_pss_fine_sync_1</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/kris/gr-lte/test/lte5framesFadingChannelETU_vec2.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>2</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>fftlen/64</value></param>
<param><key>taps</key><value>taps</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>fftlen/64</value></param>
<param><key>taps</key><value>taps</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_vector_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>lte_mimo_pss_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>lte_mimo_pss_tagger_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>lte_mimo_pss_coarse_control_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>lte_mimo_pss_coarse_control_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_tagger_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_tagger_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_coarse_sync_0</source_block_id><sink_block_id>lte_mimo_pss_tagger_0</sink_block_id><source_key>N_id_2</source_key><sink_key>N_id_2</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_coarse_control_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_coarse_control_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>lte_mimo_pss_coarse_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>lte_mimo_pss_coarse_sync_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_fine_sync_1</source_block_id><sink_block_id>lte_mimo_pss_tagger_0</sink_block_id><source_key>half_frame</source_key><sink_key>half_frame</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_fine_sync_1</source_block_id><sink_block_id>lte_mimo_pss_tagger_0</sink_block_id><source_key>lock</source_key><sink_key>lock</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_coarse_sync_0</source_block_id><sink_block_id>lte_mimo_pss_fine_sync_1</sink_block_id><source_key>N_id_2</source_key><sink_key>N_id_2</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_coarse_sync_0</source_block_id><sink_block_id>lte_mimo_pss_fine_sync_1</sink_block_id><source_key>coarse_pos</source_key><sink_key>coarse_pos</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>lte_mimo_pss_fine_sync_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>lte_mimo_pss_fine_sync_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_coarse_sync_0</source_block_id><sink_block_id>lte_mimo_pss_coarse_control_0</sink_block_id><source_key>control</source_key><sink_key>control</sink_key></connection>
</flow_graph>
