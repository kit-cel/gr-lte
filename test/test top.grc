<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slot</value></param>
<param><key>value</key><value>"slot"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_key</value></param>
<param><key>value</key><value>"slot"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>fftl*15e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftl</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxant</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/maier/Schreibtisch/lte5framesFadingChannelETU_fOff6000.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/maier/lte karlsruhe wg</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/maier/lte karlsruhe wg</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>rxant</value></param>
</block>
<block>
<key>lte_mimo_pss_sync</key>
<param><key>id</key><value>lte_mimo_pss_sync_0</value></param>
<param><key>fftlen</key><value>fftl</value></param>
<param><key>rxant</key><value>rxant</value></param>
<param><key>synclen</key><value>2</value></param>
</block>
<block>
<key>lte_mimo_pss_based_frey_sync</key>
<param><key>id</key><value>lte_mimo_pss_based_frey_sync_0</value></param>
<param><key>fftlen</key><value>1024</value></param>
<param><key>rxant</key><value>rxant</value></param>
</block>
<block>
<key>lte_mimo_sss_sync</key>
<param><key>id</key><value>lte_mimo_sss_sync_0</value></param>
<param><key>rxant</key><value>2</value></param>
<param><key>fftlen</key><value>1024</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>600</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>lte_mimo_ofdm_rx</key>
<param><key>id</key><value>lte_mimo_ofdm_rx_0</value></param>
<param><key>rxant</key><value>rxant</value></param>
<param><key>fftlen</key><value>fftl</value></param>
<param><key>ofdm_key</key><value>slot</value></param>
<param><key>N_rb_dl</key><value>50</value></param>
</block>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_throttle_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_1</source_block_id><sink_block_id>blocks_throttle_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_vector_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>lte_mimo_pss_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1_0</source_block_id><sink_block_id>lte_mimo_pss_sync_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1</source_block_id><sink_block_id>lte_mimo_pss_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_based_frey_sync_0</source_block_id><sink_block_id>lte_mimo_sss_sync_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_based_frey_sync_0</source_block_id><sink_block_id>lte_mimo_sss_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_sync_0</source_block_id><sink_block_id>lte_mimo_pss_based_frey_sync_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_sync_0</source_block_id><sink_block_id>lte_mimo_pss_based_frey_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>lte_mimo_pss_sync_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_sync_0</source_block_id><sink_block_id>lte_mimo_ofdm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_sync_0</source_block_id><sink_block_id>lte_mimo_ofdm_rx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_ofdm_rx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_ofdm_rx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
