<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>MIMO_TOP_FLOW_4_TXant</value></param>
<param><key>title</key><value>MIMO TOP FLOW 4 Tx ant</value></param>
<param><key>author</key><value>Kristian Maier</value></param>
<param><key>description</key><value>Test Top block for decoding with 4 txant</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_key</value></param>
<param><key>value</key><value>"slot"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftl</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>fftl*15e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxant</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resampler</value></param>
<param><key>value</key><value>400</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>decode_bch_hier_gr37</key>
<param><key>id</key><value>bch_decode_bch_hier_gr37_0</value></param>
</block>
<block>
<key>lte_mib_unpack_vbm</key>
<param><key>id</key><value>MIB</value></param>
</block>
<block>
<key>lte_mimo_sss_sync</key>
<param><key>id</key><value>lte_mimo_sss_sync_0</value></param>
<param><key>rxant</key><value>rxant</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1200</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>lte_mimo_decode_pbch_4_txant</key>
<param><key>id</key><value>lte_mimo_decode_pbch_4_txant_0</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>rxant</key><value>rxant</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1_1_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1200</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_1_0_1_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1200</value></param>
</block>
<block>
<key>lte_mimo_estimator_4_txant</key>
<param><key>id</key><value>lte_mimo_estimator_4_txant_0</value></param>
<param><key>estimator_key</key><value>frame_key</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>rxant</key><value>rxant</value></param>
<param><key>initial_id</key><value>333</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>1536*fftl/1024</value></param>
<param><key>decim</key><value>resampler</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>1536*fftl/1024</value></param>
<param><key>decim</key><value>resampler</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>lte_mimo_ofdm_rx</key>
<param><key>id</key><value>lte_mimo_ofdm_rx_0</value></param>
<param><key>rxant</key><value>rxant</value></param>
<param><key>fftlen</key><value>fftl</value></param>
<param><key>ofdm_key</key><value>frame_key</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_mimo_pss_sync</key>
<param><key>id</key><value>lte_mimo_pss_sync_0</value></param>
<param><key>fftlen</key><value>fftl</value></param>
<param><key>rxant</key><value>rxant</value></param>
<param><key>synclen</key><value>5</value></param>
</block>
<block>
<key>lte_mimo_pss_based_frey_sync</key>
<param><key>id</key><value>lte_mimo_pss_based_frey_sync_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fftlen</key><value>fftl</value></param>
<param><key>rxant</key><value>rxant</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>240</value></param>
</block>
<block>
<key>lte_mimo_pbch_demux</key>
<param><key>id</key><value>lte_mimo_pbch_demux_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>rxant</key><value>rxant</value></param>
</block>
<block>
<key>lte_mimo_pre_decoder</key>
<param><key>id</key><value>lte_mimo_pre_decoder_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>N_ant</key><value>1</value></param>
<param><key>vlen</key><value>240</value></param>
<param><key>style</key><value>style</value></param>
<param><key>rxant</key><value>rxant</value></param>
</block>
<block>
<key>lte_mimo_pbch_demux</key>
<param><key>id</key><value>lte_mimo_pbch_demux_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>rxant</key><value>rxant</value></param>
</block>
<block>
<key>lte_mimo_pbch_demux</key>
<param><key>id</key><value>lte_mimo_pbch_demux_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>rxant</key><value>rxant</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>2048</value></param>
</block>
<block>
<key>lte_mimo_pre_decoder</key>
<param><key>id</key><value>lte_mimo_pre_decoder_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>N_ant</key><value>2</value></param>
<param><key>vlen</key><value>240</value></param>
<param><key>style</key><value>style</value></param>
<param><key>rxant</key><value>rxant</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_1_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>240</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>2048</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/maier/LTE test files/Simulation/lte_test_data_frames50_TXant4_RXant2_10MHz_15.36MS_30db_const_channel_2_phase_cont.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_vector_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_sync_0</source_block_id><sink_block_id>lte_mimo_pss_based_frey_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_based_frey_sync_0</source_block_id><sink_block_id>lte_mimo_ofdm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_sync_0</source_block_id><sink_block_id>lte_mimo_pbch_demux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_sync_0</source_block_id><sink_block_id>lte_mimo_pbch_demux_0_1</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_sync_0</source_block_id><sink_block_id>lte_mimo_pbch_demux_0_0</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_sync_0</source_block_id><sink_block_id>lte_mimo_pbch_demux_0</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_based_frey_sync_0</source_block_id><sink_block_id>lte_mimo_ofdm_rx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_ofdm_rx_0</source_block_id><sink_block_id>lte_mimo_sss_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_sync_0</source_block_id><sink_block_id>lte_mimo_sss_sync_0</sink_block_id><source_key>N_id_2</source_key><sink_key>N_id_2</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_sync_0</source_block_id><sink_block_id>lte_mimo_pss_based_frey_sync_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_pbch_demux_0</source_block_id><sink_block_id>lte_mimo_pre_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_sync_0</source_block_id><sink_block_id>lte_mimo_estimator_4_txant_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_sync_0</source_block_id><sink_block_id>lte_mimo_estimator_4_txant_0</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_sync_0</source_block_id><sink_block_id>lte_mimo_decode_pbch_4_txant_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_estimator_4_txant_0</source_block_id><sink_block_id>lte_mimo_decode_pbch_4_txant_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_estimator_4_txant_0</source_block_id><sink_block_id>lte_mimo_decode_pbch_4_txant_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_1_0_1_2</source_block_id><sink_block_id>qtgui_const_sink_x_1_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_estimator_4_txant_0</source_block_id><sink_block_id>lte_mimo_pbch_demux_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_estimator_4_txant_0</source_block_id><sink_block_id>lte_mimo_pbch_demux_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_estimator_4_txant_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_estimator_4_txant_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_estimator_4_txant_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lte_mimo_estimator_4_txant_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>lte_mimo_decode_pbch_4_txant_0</source_block_id><sink_block_id>bch_decode_bch_hier_gr37_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_decode_bch_hier_gr37_0</source_block_id><sink_block_id>MIB</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_decode_bch_hier_gr37_0</source_block_id><sink_block_id>MIB</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>rational_resampler_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1</source_block_id><sink_block_id>lte_mimo_pss_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>lte_mimo_pss_sync_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_sync_0</source_block_id><sink_block_id>lte_mimo_decode_pbch_4_txant_0</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>lte_mimo_estimator_4_txant_0</source_block_id><sink_block_id>lte_mimo_decode_pbch_4_txant_0</sink_block_id><source_key>2</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>lte_mimo_estimator_4_txant_0</source_block_id><sink_block_id>lte_mimo_decode_pbch_4_txant_0</sink_block_id><source_key>3</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>lte_mimo_estimator_4_txant_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_1_0_1_2</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>lte_mimo_pss_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>lte_mimo_pss_sync_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_sync_0</source_block_id><sink_block_id>lte_mimo_ofdm_rx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_pss_sync_0</source_block_id><sink_block_id>lte_mimo_ofdm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_pre_decoder_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_pre_decoder_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_pbch_demux_0</source_block_id><sink_block_id>lte_mimo_pre_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_pbch_demux_0_0</source_block_id><sink_block_id>lte_mimo_pre_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_pbch_demux_0_1</source_block_id><sink_block_id>lte_mimo_pre_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_1_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_pbch_demux_0_0</source_block_id><sink_block_id>lte_mimo_pre_decoder_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_1_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
