<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_mimo_sss_sync</value></param>
<param><key>title</key><value>LTE MIMO SSS sync</value></param>
<param><key>author</key><value>Kristian Maier</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rxant</value></param>
<param><key>label</key><value>RX antennas</value></param>
<param><key>value</key><value>2</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>label</key><value>FFT length</value></param>
<param><key>value</key><value>1024</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>sync_sss_fft_vxx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fftlen</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(fftlen)</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>sync_sss_fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fftlen</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(fftlen)</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>lte_mimo_sss_symbol_selector</key>
<param><key>id</key><value>lte_mimo_sss_symbol_selector_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
<param><key>rxant</key><value>rxant</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>rxant</value></param>
</block>
<block>
<key>lte_extract_subcarriers_vcvc</key>
<param><key>id</key><value>sync_sss_extract_subcarriers_vcvc_0_0</value></param>
<param><key>N_rb_dl</key><value>6</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>lte_extract_subcarriers_vcvc</key>
<param><key>id</key><value>sync_sss_extract_subcarriers_vcvc_0</value></param>
<param><key>N_rb_dl</key><value>6</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>lte_mimo_sss_calculator</key>
<param><key>id</key><value>lte_mimo_sss_calculator_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
<param><key>rxant</key><value>rxant</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0</value></param>
<param><key>label</key><value>cell_id</value></param>
<param><key>type</key><value>message</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>lte_mimo_sss_tagger</key>
<param><key>id</key><value>lte_mimo_sss_tagger_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
<param><key>rxant</key><value>rxant</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>rxant</value></param>
</block>
<connection><source_block_id>sync_sss_fft_vxx_0_0</source_block_id><sink_block_id>sync_sss_extract_subcarriers_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_sss_fft_vxx_0</source_block_id><sink_block_id>sync_sss_extract_subcarriers_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_symbol_selector_0</source_block_id><sink_block_id>sync_sss_fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_symbol_selector_0</source_block_id><sink_block_id>sync_sss_fft_vxx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>lte_mimo_sss_symbol_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>lte_mimo_sss_symbol_selector_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_tagger_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_tagger_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>lte_mimo_sss_tagger_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>lte_mimo_sss_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_calculator_0</source_block_id><sink_block_id>pad_sink_0_0_0</sink_block_id><source_key>cell_id</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_calculator_0</source_block_id><sink_block_id>lte_mimo_sss_tagger_0</sink_block_id><source_key>frame_start</source_key><sink_key>frame_start</sink_key></connection>
<connection><source_block_id>sync_sss_extract_subcarriers_vcvc_0_0</source_block_id><sink_block_id>lte_mimo_sss_calculator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_sss_extract_subcarriers_vcvc_0</source_block_id><sink_block_id>lte_mimo_sss_calculator_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
