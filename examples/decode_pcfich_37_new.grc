<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>N_ant_dummy</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>style</value></param>
<param><key>value</key><value>"tx_diversity"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vlen</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>label</key><value>resource blocks</value></param>
<param><key>value</key><value>50</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_key</value></param>
<param><key>label</key><value>Frame Indicator Key</value></param>
<param><key>value</key><value>"slot"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfi_sf_key</value></param>
<param><key>label</key><value>PCFICH subframe key</value></param>
<param><key>value</key><value>"subframe"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>lte_pre_decoder_vcvc</key>
<param><key>id</key><value>lte_pre_decoder_vcvc_0</value></param>
<param><key>N_ant</key><value>N_ant_dummy</value></param>
<param><key>vlen</key><value>vlen</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>lte_layer_demapper_vcvc</key>
<param><key>id</key><value>lte_layer_demapper_vcvc_0</value></param>
<param><key>N_ant</key><value>N_ant_dummy</value></param>
<param><key>vlen</key><value>vlen</value></param>
<param><key>style</key><value>style</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>z_N_ant</value></param>
<param><key>label</key><value>N_ant</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>z_cell_id</value></param>
<param><key>label</key><value>cell_id</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>cfi_msg</value></param>
<param><key>label</key><value>CFI</value></param>
<param><key>type</key><value>message</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>lte_qpsk_soft_demod_vcvf</key>
<param><key>id</key><value>lte_qpsk_soft_demod_vcvf_0</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>lte_decode_pcfich_hier</value></param>
<param><key>title</key><value>Decode PCFICH</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>description</key><value>hierarchical block to sum up blocks and variables needed for PCFICH</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<connection><source_block_id>lte_pre_decoder_vcvc_0</source_block_id><sink_block_id>lte_layer_demapper_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_layer_demapper_vcvc_0</source_block_id><sink_block_id>lte_qpsk_soft_demod_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>z_N_ant</source_block_id><sink_block_id>lte_layer_demapper_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>N_ant</sink_key></connection>
</flow_graph>
