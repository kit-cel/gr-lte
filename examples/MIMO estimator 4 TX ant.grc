<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>parameter</key>
<param><key>id</key><value>rxant</value></param>
<param><key>label</key><value>RX antennas</value></param>
<param><key>value</key><value>2</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mymap3</value></param>
<param><key>value</key><value>lte.frame_pilot_value_and_position(N_rb_dl, initial_id, 1, 3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mymap2</value></param>
<param><key>value</key><value>lte.frame_pilot_value_and_position(N_rb_dl, initial_id, 1, 2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mymap0</value></param>
<param><key>value</key><value>lte.frame_pilot_value_and_position(N_rb_dl, initial_id, 1, 0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mymap1</value></param>
<param><key>value</key><value>lte.frame_pilot_value_and_position(N_rb_dl, initial_id, 1, 1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>poss3</value></param>
<param><key>value</key><value>mymap3[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vals3</value></param>
<param><key>value</key><value>mymap3[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>poss2</value></param>
<param><key>value</key><value>mymap2[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vals0</value></param>
<param><key>value</key><value>mymap0[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>poss0</value></param>
<param><key>value</key><value>mymap0[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vals1</value></param>
<param><key>value</key><value>mymap1[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>poss1</value></param>
<param><key>value</key><value>mymap1[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vals2</value></param>
<param><key>value</key><value>mymap2[1]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>initial_id</value></param>
<param><key>label</key><value>initial Cell ID</value></param>
<param><key>value</key><value>333</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>estimator_key</value></param>
<param><key>label</key><value>Tag Key</value></param>
<param><key>value</key><value>slot</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>label</key><value>resource blocks</value></param>
<param><key>value</key><value>50</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import lte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>cell_id</value></param>
<param><key>label</key><value>cell_id</value></param>
<param><key>type</key><value>message</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>lte_mimo_channel_estimator</key>
<param><key>id</key><value>lte_mimo_channel_estimator_0</value></param>
<param><key>subcarriers</key><value>N_rb_dl*12</value></param>
<param><key>rxant</key><value>rxant</value></param>
<param><key>tag_key</key><value>estimator_key</value></param>
<param><key>pilot_carriers</key><value>poss0</value></param>
<param><key>pilot_symbols</key><value>vals0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>ant_p0_est</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl*rxant</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>label</key><value>ant_p1_est</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl*rxant</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>label</key><value>ant_p3_est</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl*rxant</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>ain0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl*rxant</value></param>
</block>
<block>
<key>lte_rs_map_generator_m</key>
<param><key>id</key><value>ofdm_estimator_lte_rs_map_generator_m_0</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>ant_port</key><value>0</value></param>
</block>
<block>
<key>lte_rs_map_generator_m</key>
<param><key>id</key><value>ofdm_estimator_lte_rs_map_generator_m_1</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>ant_port</key><value>1</value></param>
</block>
<block>
<key>lte_rs_map_generator_m</key>
<param><key>id</key><value>ofdm_estimator_lte_rs_map_generator_m_0_0</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>ant_port</key><value>2</value></param>
</block>
<block>
<key>lte_rs_map_generator_m</key>
<param><key>id</key><value>ofdm_estimator_lte_rs_map_generator_m_1_0</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>ant_port</key><value>3</value></param>
</block>
<block>
<key>lte_mimo_channel_estimator</key>
<param><key>id</key><value>lte_mimo_channel_estimator_0_0</value></param>
<param><key>subcarriers</key><value>N_rb_dl*12</value></param>
<param><key>rxant</key><value>rxant</value></param>
<param><key>tag_key</key><value>estimator_key</value></param>
<param><key>pilot_carriers</key><value>poss1</value></param>
<param><key>pilot_symbols</key><value>vals1</value></param>
</block>
<block>
<key>lte_mimo_channel_estimator</key>
<param><key>id</key><value>lte_mimo_channel_estimator_0_1</value></param>
<param><key>subcarriers</key><value>N_rb_dl*12</value></param>
<param><key>rxant</key><value>rxant</value></param>
<param><key>tag_key</key><value>estimator_key</value></param>
<param><key>pilot_carriers</key><value>poss2</value></param>
<param><key>pilot_symbols</key><value>vals2</value></param>
</block>
<block>
<key>lte_mimo_channel_estimator</key>
<param><key>id</key><value>lte_mimo_channel_estimator_0_0_0</value></param>
<param><key>subcarriers</key><value>N_rb_dl*12</value></param>
<param><key>rxant</key><value>rxant</value></param>
<param><key>tag_key</key><value>estimator_key</value></param>
<param><key>pilot_carriers</key><value>poss3</value></param>
<param><key>pilot_symbols</key><value>vals3</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>label</key><value>ant_p2_est</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl*rxant</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>lte_mimo_estimator_4_txant</value></param>
<param><key>title</key><value>LTE MIMO estimator 4 txant</value></param>
<param><key>author</key><value>Kristian Maier, Johannes Demel</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<connection><source_block_id>cell_id</source_block_id><sink_block_id>ofdm_estimator_lte_rs_map_generator_m_0</sink_block_id><source_key>0</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>cell_id</source_block_id><sink_block_id>ofdm_estimator_lte_rs_map_generator_m_1</sink_block_id><source_key>0</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>ofdm_estimator_lte_rs_map_generator_m_0</source_block_id><sink_block_id>lte_mimo_channel_estimator_0</sink_block_id><source_key>pilots</source_key><sink_key>pilots</sink_key></connection>
<connection><source_block_id>ofdm_estimator_lte_rs_map_generator_m_1</source_block_id><sink_block_id>lte_mimo_channel_estimator_0_0</sink_block_id><source_key>pilots</source_key><sink_key>pilots</sink_key></connection>
<connection><source_block_id>ain0</source_block_id><sink_block_id>lte_mimo_channel_estimator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ain0</source_block_id><sink_block_id>lte_mimo_channel_estimator_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_channel_estimator_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_channel_estimator_0_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_estimator_lte_rs_map_generator_m_0_0</source_block_id><sink_block_id>lte_mimo_channel_estimator_0_1</sink_block_id><source_key>pilots</source_key><sink_key>pilots</sink_key></connection>
<connection><source_block_id>ofdm_estimator_lte_rs_map_generator_m_1_0</source_block_id><sink_block_id>lte_mimo_channel_estimator_0_0_0</sink_block_id><source_key>pilots</source_key><sink_key>pilots</sink_key></connection>
<connection><source_block_id>lte_mimo_channel_estimator_0_1</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_channel_estimator_0_0_0</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cell_id</source_block_id><sink_block_id>ofdm_estimator_lte_rs_map_generator_m_0_0</sink_block_id><source_key>0</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>cell_id</source_block_id><sink_block_id>ofdm_estimator_lte_rs_map_generator_m_1_0</sink_block_id><source_key>0</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>ain0</source_block_id><sink_block_id>lte_mimo_channel_estimator_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ain0</source_block_id><sink_block_id>lte_mimo_channel_estimator_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
