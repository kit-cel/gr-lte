<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_top_block_mimo_4tx</value></param>
<param><key>author</key><value>Kristian Maier, Johannes Demel</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>LTE decoding up to 4 tx antennas</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>MIMO TOP FLOW 4 Tx ant</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftl</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_key</value></param>
<param><key>value</key><value>"slot"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resampler</value></param>
<param><key>value</key><value>400</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxant</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>fftl*15e3</value></param>
</block>
<block>
<key>lte_mib_unpack_vbm</key>
<param><key>id</key><value>MIB</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/maier/LTE test files/live data/lte_capture_Wed_Aug_6_19:36:39_2014_RXant2_4MS_telekom_band1800_wg_karlruhe_hinten raus_messung1.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12 * N_rb_dl</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>lte_bch_decoder</key>
<param><key>id</key><value>lte_bch_decoder_0</value></param>
</block>
<block>
<key>lte_channel_estimator_mimo_4tx</key>
<param><key>id</key><value>lte_channel_estimator_mimo_4tx_0</value></param>
<param><key>rxant</key><value>rxant</value></param>
<param><key>estimator_key</key><value>"slot"</value></param>
<param><key>initial_id</key><value>333</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_cp_ffo_sync_mimo_2tx</key>
<param><key>id</key><value>lte_cp_ffo_sync_mimo_2tx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftlen</key><value>fftl</value></param>
<param><key>rxant</key><value>rxant</value></param>
</block>
<block>
<key>lte_ofdm_demodulator_mimo_2tx</key>
<param><key>id</key><value>lte_ofdm_demodulator_mimo_2tx_0</value></param>
<param><key>fftlen</key><value>fftl</value></param>
<param><key>rxant</key><value>rxant</value></param>
<param><key>ofdm_key</key><value>"slot"</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_pbch_decoder_mimo_4tx</key>
<param><key>id</key><value>lte_pbch_decoder_mimo_4tx_0</value></param>
<param><key>rxant</key><value>rxant</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_pss_sync_direct_mimo_2tx</key>
<param><key>id</key><value>lte_pss_sync_direct_mimo_2tx_0</value></param>
<param><key>fftlen</key><value>fftl</value></param>
<param><key>rxant</key><value>rxant</value></param>
<param><key>synclen</key><value>5</value></param>
</block>
<block>
<key>lte_sss_sync_freq_domain_mimo_2tx</key>
<param><key>id</key><value>lte_sss_sync_freq_domain_mimo_2tx_0</value></param>
<param><key>rxant</key><value>rxant</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>resampler</value></param>
<param><key>interp</key><value>1536*fftl/1024</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1</value></param>
<param><key>decim</key><value>resampler</value></param>
<param><key>interp</key><value>1536*fftl/1024</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_0_0</source_block_id><sink_block_id>lte_channel_estimator_mimo_4tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_0_0</source_block_id><sink_block_id>lte_pbch_decoder_mimo_4tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_vector_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>rational_resampler_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_bch_decoder_0</source_block_id><sink_block_id>MIB</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_bch_decoder_0</source_block_id><sink_block_id>MIB</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_mimo_4tx_0</source_block_id><sink_block_id>lte_pbch_decoder_mimo_4tx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_mimo_4tx_0</source_block_id><sink_block_id>lte_pbch_decoder_mimo_4tx_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_mimo_4tx_0</source_block_id><sink_block_id>lte_pbch_decoder_mimo_4tx_0</sink_block_id><source_key>2</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>lte_channel_estimator_mimo_4tx_0</source_block_id><sink_block_id>lte_pbch_decoder_mimo_4tx_0</sink_block_id><source_key>3</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>lte_cp_ffo_sync_mimo_2tx_0</source_block_id><sink_block_id>lte_ofdm_demodulator_mimo_2tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_cp_ffo_sync_mimo_2tx_0</source_block_id><sink_block_id>lte_ofdm_demodulator_mimo_2tx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_ofdm_demodulator_mimo_2tx_0</source_block_id><sink_block_id>lte_sss_sync_freq_domain_mimo_2tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_ofdm_demodulator_mimo_2tx_0</source_block_id><sink_block_id>lte_sss_sync_freq_domain_mimo_2tx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_pbch_decoder_mimo_4tx_0</source_block_id><sink_block_id>lte_bch_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pss_sync_direct_mimo_2tx_0</source_block_id><sink_block_id>lte_sss_sync_freq_domain_mimo_2tx_0</sink_block_id><source_key>N_id_2</source_key><sink_key>N_id_2</sink_key></connection>
<connection><source_block_id>lte_pss_sync_direct_mimo_2tx_0</source_block_id><sink_block_id>lte_cp_ffo_sync_mimo_2tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pss_sync_direct_mimo_2tx_0</source_block_id><sink_block_id>lte_ofdm_demodulator_mimo_2tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_pss_sync_direct_mimo_2tx_0</source_block_id><sink_block_id>lte_cp_ffo_sync_mimo_2tx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_pss_sync_direct_mimo_2tx_0</source_block_id><sink_block_id>lte_ofdm_demodulator_mimo_2tx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_sss_sync_freq_domain_mimo_2tx_0</source_block_id><sink_block_id>lte_channel_estimator_mimo_4tx_0</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>lte_sss_sync_freq_domain_mimo_2tx_0</source_block_id><sink_block_id>lte_pbch_decoder_mimo_4tx_0</sink_block_id><source_key>cell_id</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>lte_sss_sync_freq_domain_mimo_2tx_0</source_block_id><sink_block_id>blocks_streams_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_sss_sync_freq_domain_mimo_2tx_0</source_block_id><sink_block_id>blocks_streams_to_vector_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>lte_pss_sync_direct_mimo_2tx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1</source_block_id><sink_block_id>lte_pss_sync_direct_mimo_2tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
