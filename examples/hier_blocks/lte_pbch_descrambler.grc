<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_pbch_descrambler</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>category</key><value>lte</value></param>
<param><key>description</key><value>Block to descramble PBCH</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>PBCH Descrambler</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import lte</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
<param><key>vlen</key><value>120</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>480</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1_0</value></param>
<param><key>label</key><value>cell_id</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>pbch_descr_blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>vlen</key><value>120</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>pbch_descr_blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>[1/4.0]*120</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>120</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>pbch_descr_blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1920</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>pbch_descr_blocks_repeat_0</value></param>
<param><key>interp</key><value>4</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>480</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>pbch_descr_blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>(4, 1)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>120</value></param>
</block>
<block>
<key>blocks_stream_to_streams</key>
<param><key>id</key><value>pbch_descr_blocks_stream_to_streams_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>4</value></param>
<param><key>vlen</key><value>120</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>pbch_descr_blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>4</value></param>
<param><key>vlen</key><value>480</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>pbch_descr_blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>16</value></param>
<param><key>vlen</key><value>120</value></param>
</block>
<block>
<key>lte_repeat_message_source_vf</key>
<param><key>id</key><value>pbch_descr_repeat_message_source_vf_0</value></param>
<param><key>vector_len</key><value>1920</value></param>
</block>
<block>
<key>lte_pbch_scramble_sequencer_m</key>
<param><key>id</key><value>pbch_descr_scramble_sequencer_m_0</value></param>
</block>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>pbch_descr_blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1_0</source_block_id><sink_block_id>pbch_descr_scramble_sequencer_m_0</sink_block_id><source_key>out</source_key><sink_key>cell_id</sink_key></connection>
<connection><source_block_id>pbch_descr_blocks_add_xx_0</source_block_id><sink_block_id>pbch_descr_blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pbch_descr_blocks_multiply_const_vxx_0</source_block_id><sink_block_id>pbch_descr_blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pbch_descr_blocks_multiply_xx_0</source_block_id><sink_block_id>pbch_descr_blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pbch_descr_blocks_repeat_0</source_block_id><sink_block_id>pbch_descr_blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pbch_descr_blocks_stream_mux_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pbch_descr_blocks_stream_to_streams_0</source_block_id><sink_block_id>pbch_descr_blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pbch_descr_blocks_stream_to_streams_0</source_block_id><sink_block_id>pbch_descr_blocks_add_xx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pbch_descr_blocks_stream_to_streams_0</source_block_id><sink_block_id>pbch_descr_blocks_add_xx_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pbch_descr_blocks_stream_to_streams_0</source_block_id><sink_block_id>pbch_descr_blocks_add_xx_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pbch_descr_blocks_stream_to_vector_0</source_block_id><sink_block_id>pbch_descr_blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pbch_descr_blocks_vector_to_stream_0</source_block_id><sink_block_id>pbch_descr_blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pbch_descr_blocks_vector_to_stream_0</source_block_id><sink_block_id>pbch_descr_blocks_stream_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pbch_descr_repeat_message_source_vf_0</source_block_id><sink_block_id>pbch_descr_blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pbch_descr_scramble_sequencer_m_0</source_block_id><sink_block_id>pbch_descr_repeat_message_source_vf_0</sink_block_id><source_key>vector</source_key><sink_key>vector</sink_key></connection>
</flow_graph>
