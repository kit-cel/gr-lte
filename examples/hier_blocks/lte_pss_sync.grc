<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_pss_sync</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>category</key><value>lte</value></param>
<param><key>description</key><value>hierarchical blocks for PSS synchronization</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>LTE PSS Sync</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_rb_dl_pss</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>label</key><value>FFT length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>lte_pss_calculator_vcm</key>
<param><key>id</key><value>sync_pss_calculator_vcm_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>sync_pss_fft_vxx_0</value></param>
<param><key>fft_size</key><value>fftlen</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value>window.rectangular(fftlen)</value></param>
</block>
<block>
<key>lte_extract_subcarriers_vcvc</key>
<param><key>id</key><value>sync_pss_lte_extract_subcarriers_vcvc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl_pss</value></param>
</block>
<block>
<key>lte_pss_symbol_selector_cvc</key>
<param><key>id</key><value>sync_pss_symbol_selector_cvc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>lte_pss_tagger_cc</key>
<param><key>id</key><value>sync_pss_tagger_cc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>sync_pss_symbol_selector_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>sync_pss_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_pss_calculator_vcm_0</source_block_id><sink_block_id>sync_pss_tagger_cc_0</sink_block_id><source_key>N_id_2</source_key><sink_key>N_id_2</sink_key></connection>
<connection><source_block_id>sync_pss_calculator_vcm_0</source_block_id><sink_block_id>sync_pss_symbol_selector_cvc_0</sink_block_id><source_key>half_frame</source_key><sink_key>half_frame</sink_key></connection>
<connection><source_block_id>sync_pss_calculator_vcm_0</source_block_id><sink_block_id>sync_pss_tagger_cc_0</sink_block_id><source_key>half_frame</source_key><sink_key>half_frame</sink_key></connection>
<connection><source_block_id>sync_pss_calculator_vcm_0</source_block_id><sink_block_id>sync_pss_symbol_selector_cvc_0</sink_block_id><source_key>lock</source_key><sink_key>lock</sink_key></connection>
<connection><source_block_id>sync_pss_calculator_vcm_0</source_block_id><sink_block_id>sync_pss_tagger_cc_0</sink_block_id><source_key>lock</source_key><sink_key>lock</sink_key></connection>
<connection><source_block_id>sync_pss_fft_vxx_0</source_block_id><sink_block_id>sync_pss_lte_extract_subcarriers_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_pss_lte_extract_subcarriers_vcvc_0</source_block_id><sink_block_id>sync_pss_calculator_vcm_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_pss_symbol_selector_cvc_0</source_block_id><sink_block_id>sync_pss_fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_pss_tagger_cc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
