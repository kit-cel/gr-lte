<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_sss_sync_freq_domain_mimo_2tx</value></param>
<param><key>author</key><value>Kristian Maier</value></param>
<param><key>category</key><value>lte</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>SSS Sync frequency Domain MIMO 2TX</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>label</key><value>resource blocks</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>72</value></param>
</block>
<block>
<key>lte_mimo_sss_calculator</key>
<param><key>id</key><value>lte_mimo_sss_calculator_0</value></param>
<param><key>rxant</key><value>rxant</value></param>
</block>
<block>
<key>lte_mimo_sss_symbol_selector</key>
<param><key>id</key><value>lte_mimo_sss_symbol_selector_0_0</value></param>
<param><key>rxant</key><value>1</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_mimo_sss_symbol_selector</key>
<param><key>id</key><value>lte_mimo_sss_symbol_selector_0_0_0</value></param>
<param><key>rxant</key><value>1</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_mimo_sss_tagger</key>
<param><key>id</key><value>lte_mimo_sss_tagger_0</value></param>
<param><key>rxant</key><value>1</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>lte_mimo_sss_tagger</key>
<param><key>id</key><value>lte_mimo_sss_tagger_0_0</value></param>
<param><key>rxant</key><value>1</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
<param><key>num_streams</key><value>rxant</value></param>
<param><key>vlen</key><value>N_rb_dl*12</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>cell_id</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>num_streams</key><value>rxant</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>N_rb_dl*12</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>N_id_2</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rxant</value></param>
<param><key>label</key><value>RX antennas</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<connection><source_block_id>blocks_streams_to_vector_0</source_block_id><sink_block_id>lte_mimo_sss_calculator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_calculator_0</source_block_id><sink_block_id>pad_sink_0_0_0</sink_block_id><source_key>cell_id</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_calculator_0</source_block_id><sink_block_id>lte_mimo_sss_tagger_0</sink_block_id><source_key>frame_start</source_key><sink_key>frame_start</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_calculator_0</source_block_id><sink_block_id>lte_mimo_sss_tagger_0_0</sink_block_id><source_key>frame_start</source_key><sink_key>frame_start</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_symbol_selector_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_symbol_selector_0_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_tagger_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_sss_tagger_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>lte_mimo_sss_symbol_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>lte_mimo_sss_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>lte_mimo_sss_symbol_selector_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>lte_mimo_sss_tagger_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>lte_mimo_sss_calculator_0</sink_block_id><source_key>out</source_key><sink_key>N_id_2</sink_key></connection>
</flow_graph>
