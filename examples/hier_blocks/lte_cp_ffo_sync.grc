<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_cp_ffo_sync</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>category</key><value>lte</value></param>
<param><key>description</key><value>Cyclic Prefix based synchronization for the fractional frequency offset</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>CP-based FFO Sync</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp0</value></param>
<param><key>value</key><value>160 * (fftlen/2048)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp1</value></param>
<param><key>value</key><value>144 * (fftlen/2048)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>slotl/0.0005</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slotl</value></param>
<param><key>value</key><value>7 * fftlen + 6 * cp1 + cp0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>label</key><value>FFT length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>lte_sync_frequency_c</key>
<param><key>id</key><value>sync_ffofrac_lte_sync_frequency_c_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
<param><key>sig</key><value>"sync_ffofrac_sig"</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>sync_ffofrac_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>sync_ffofrac_sig</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>sync_ffofrac_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_ffofrac_multiply_xx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_ffofrac_multiply_xx_0</source_block_id><sink_block_id>sync_ffofrac_lte_sync_frequency_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_ffofrac_sig</source_block_id><sink_block_id>sync_ffofrac_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
