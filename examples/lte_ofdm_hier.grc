<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_ofdm_hier</value></param>
<param><key>title</key><value>LTE OFDM RX</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>description</key><value>OFDM RX operations</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_rb_dl</value></param>
<param><key>label</key><value>resource blocks</value></param>
<param><key>value</key><value>50</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>label</key><value>FFT length</value></param>
<param><key>value</key><value>2048</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ofdm_key</value></param>
<param><key>label</key><value>Tag Key</value></param>
<param><key>value</key><value>slot</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>lte_extract_subcarriers_vcvc</key>
<param><key>id</key><value>ofdm_lte_extract_subcarriers_vcvc_0</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>12*N_rb_dl</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>ofdm_fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fftlen</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(fftlen)</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>lte_remove_cp_cvc</key>
<param><key>id</key><value>ofdm_lte_remove_cp_cvc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
<param><key>key</key><value>ofdm_key</value></param>
</block>
<block>
<key>lte_mimo_remove_cp</key>
<param><key>id</key><value>lte_mimo_remove_cp_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fftl</key><value>fftlen</value></param>
<param><key>rxant</key><value>1</value></param>
<param><key>key</key><value>ofdm_key</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ofdm_lte_remove_cp_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_fft_vxx_0</source_block_id><sink_block_id>ofdm_lte_extract_subcarriers_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_lte_remove_cp_cvc_0</source_block_id><sink_block_id>ofdm_fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_lte_extract_subcarriers_vcvc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>lte_mimo_remove_cp_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lte_mimo_remove_cp_0</source_block_id><sink_block_id>ofdm_fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
