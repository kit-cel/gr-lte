options:
  parameters:
    author: Johannes Demel
    category: lte
    generate_options: qt_gui
    id: lte_top_block_siso
    output_language: python
    thread_safe_setters: '1'
    title: LTE top level flowgraph SISO
  states: {}

blocks:
- name: N_rb_dl
  id: variable
  parameters:
    value: '50'
  states: {}
- name: fc2
  id: variable_qtgui_range
  parameters:
    label: Freq
    min_len: '800'
    orient: Qt.Horizontal
    start: '8006'
    step: 1e6
    stop: 1900e6
    value: fc
  states: {}
- name: fftlen
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: frame_key
  id: variable
  parameters:
    value: '"slot"'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: interp_val
  id: variable
  parameters:
    value: int(samp_rate/1e4)
  states: {}
- name: pbch_descr_key
  id: variable
  parameters:
    value: '"descr_part"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (7*fftlen + 160* fftlen/2048 + 6 * (144 * fftlen/2048)) / 0.0005
  states: {}
- name: show_id
  id: variable
  parameters:
    value: '1'
  states: {}
- name: MIB
  id: lte_mib_unpack_vbm
  parameters: {}
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate * 2)
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: fc
  id: parameter
  parameters:
    label: LTE
    short_id: f
    type: eng_float
    value: 801e6
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    calibr_bandw_ch0: 10e6
    channel_mode: '0'
    digital_bandw_ch0: '0'
    gain_dB_ch0: gain
    lna_path_ch0: '3'
    oversample: '0'
    rf_freq: fc2
    samp_rate: samp_rate
    serial: 1D424AFB4F4F9A
  states: {}
- name: lte_bch_decoder_0
  id: lte_bch_decoder
  parameters: {}
  states: {}
- name: lte_channel_estimator_0
  id: lte_channel_estimator
  parameters:
    N_rb_dl: N_rb_dl
    estimator_key: frame_key
    initial_id: '124'
  states: {}
- name: lte_cp_ffo_sync_0
  id: lte_cp_ffo_sync
  parameters:
    fftlen: fftlen
  states: {}
- name: lte_ofdm_demodulator_0
  id: lte_ofdm_demodulator
  parameters:
    N_rb_dl: N_rb_dl
    fftlen: fftlen
    ofdm_key: frame_key
  states: {}
- name: lte_pbch_decoder_0
  id: lte_pbch_decoder
  parameters:
    N_rb_dl: N_rb_dl
  states: {}
- name: lte_pcfich_decoder_0
  id: lte_pcfich_decoder
  parameters:
    N_rb_dl: N_rb_dl
    key: frame_key
  states: {}
- name: lte_pss_sync_0
  id: lte_pss_sync
  parameters:
    fftlen: fftlen
  states: {}
- name: lte_sss_sync_0
  id: lte_sss_sync
  parameters:
    N_rb_dl: N_rb_dl
    fftlen: fftlen
    group_key: '''N_id_2'''
    offset_key: '''offset_marker'''
  states: {}
- name: pre_rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1000'
    interp: interp_val
    taps: ''
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: sync_lte_rough_symbol_sync_cc_0
  id: lte_rough_symbol_sync_cc
  parameters:
    fftl: fftlen
    vlen: '1'
  states: {}

connections:
- [MIB, N_ant, lte_pcfich_decoder_0, N_ant]
- [blocks_add_xx_0, '0', blocks_head_0_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_deinterleave_0, '0', blocks_add_xx_0, '1']
- [blocks_deinterleave_0, '1', blocks_add_xx_0, '0']
- [blocks_head_0_0, '0', blocks_throttle_0, '0']
- [limesdr_source_0, '0', blocks_head_0_0, '0']
- [limesdr_source_0, '0', pre_rational_resampler_xxx_0, '0']
- [limesdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [lte_bch_decoder_0, '0', MIB, '0']
- [lte_bch_decoder_0, '1', MIB, '1']
- [lte_channel_estimator_0, '0', lte_pbch_decoder_0, '1']
- [lte_channel_estimator_0, '0', lte_pcfich_decoder_0, '1']
- [lte_channel_estimator_0, '1', lte_pbch_decoder_0, '2']
- [lte_channel_estimator_0, '1', lte_pcfich_decoder_0, '2']
- [lte_cp_ffo_sync_0, '0', lte_sss_sync_0, '0']
- [lte_ofdm_demodulator_0, '0', lte_channel_estimator_0, '0']
- [lte_ofdm_demodulator_0, '0', lte_pbch_decoder_0, '0']
- [lte_ofdm_demodulator_0, '0', lte_pcfich_decoder_0, '0']
- [lte_pbch_decoder_0, '0', lte_bch_decoder_0, '0']
- [lte_pss_sync_0, '0', lte_cp_ffo_sync_0, '0']
- [lte_sss_sync_0, '0', lte_ofdm_demodulator_0, '0']
- [lte_sss_sync_0, cell_id, lte_channel_estimator_0, cell_id]
- [lte_sss_sync_0, cell_id, lte_pbch_decoder_0, cell_id]
- [lte_sss_sync_0, cell_id, lte_pcfich_decoder_0, cell_id]
- [pre_rational_resampler_xxx_0, '0', sync_lte_rough_symbol_sync_cc_0, '0']
- [sync_lte_rough_symbol_sync_cc_0, '0', lte_pss_sync_0, '0']

metadata:
  file_format: 1
