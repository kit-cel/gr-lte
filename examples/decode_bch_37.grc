<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>decode_bch_hier_gr37</value></param>
<param><key>title</key><value>Decode BCH 3.7</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>description</key><value>GR 3.7 hier block for LTE BCH decoding</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>lte</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>final_xor2</value></param>
<param><key>value</key><value>65535</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>final_xor4</value></param>
<param><key>value</key><value>21845</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>final_xor1</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_len</value></param>
<param><key>value</key><value>24</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>label</key><value>N_ant</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>mib</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>24</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>bch_blocks_vector_to_stream_0_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>3</value></param>
<param><key>vlen</key><value>40</value></param>
</block>
<block>
<key>blocks_stream_to_streams</key>
<param><key>id</key><value>bch_blocks_stream_to_streams_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>3</value></param>
<param><key>vlen</key><value>40</value></param>
</block>
<block>
<key>lte_subblock_deinterleaver_vfvf</key>
<param><key>id</key><value>bch_lte_subblock_deinterleaver_vfvf_0</value></param>
<param><key>num_groups</key><value>40</value></param>
<param><key>items_per_group</key><value>1</value></param>
</block>
<block>
<key>lte_subblock_deinterleaver_vfvf</key>
<param><key>id</key><value>bch_lte_subblock_deinterleaver_vfvf_0_1</value></param>
<param><key>num_groups</key><value>40</value></param>
<param><key>items_per_group</key><value>1</value></param>
</block>
<block>
<key>lte_subblock_deinterleaver_vfvf</key>
<param><key>id</key><value>bch_lte_subblock_deinterleaver_vfvf_0_0</value></param>
<param><key>num_groups</key><value>40</value></param>
<param><key>items_per_group</key><value>1</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>bch_blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>40</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>bch_blocks_vector_to_stream_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>40</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>bch_blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>40</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>bch_blocks_interleave_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>3</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>bch_blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>120</value></param>
</block>
<block>
<key>lte_bch_viterbi_vfvb</key>
<param><key>id</key><value>bch_lte_bch_viterbi_vfvb_0</value></param>
</block>
<block>
<key>lte_crc_check_vbvb</key>
<param><key>id</key><value>bch_lte_crc_check_vbvb_0_2</value></param>
<param><key>data_len</key><value>data_len</value></param>
<param><key>final_xor</key><value>final_xor1</value></param>
</block>
<block>
<key>lte_crc_check_vbvb</key>
<param><key>id</key><value>bch_lte_crc_check_vbvb_0</value></param>
<param><key>data_len</key><value>data_len</value></param>
<param><key>final_xor</key><value>final_xor4</value></param>
</block>
<block>
<key>lte_crc_check_vbvb</key>
<param><key>id</key><value>bch_lte_crc_check_vbvb_0_0</value></param>
<param><key>data_len</key><value>data_len</value></param>
<param><key>final_xor</key><value>final_xor2</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>bch_blocks_null_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>data_len</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>bch_blocks_null_sink_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>data_len</value></param>
</block>
<block>
<key>lte_bch_crc_check_ant_chooser_bb</key>
<param><key>id</key><value>bch_lte_bch_crc_check_ant_chooser_bb_0</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>120</value></param>
</block>
<connection><source_block_id>bch_blocks_stream_to_vector_0</source_block_id><sink_block_id>bch_lte_bch_viterbi_vfvb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_blocks_vector_to_stream_0_2</source_block_id><sink_block_id>bch_blocks_stream_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source</source_block_id><sink_block_id>bch_blocks_vector_to_stream_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_lte_bch_crc_check_ant_chooser_bb_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_lte_crc_check_vbvb_0_2</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_lte_crc_check_vbvb_0_2</source_block_id><sink_block_id>bch_lte_bch_crc_check_ant_chooser_bb_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_lte_crc_check_vbvb_0_0</source_block_id><sink_block_id>bch_blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_lte_crc_check_vbvb_0</source_block_id><sink_block_id>bch_blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_lte_crc_check_vbvb_0</source_block_id><sink_block_id>bch_lte_bch_crc_check_ant_chooser_bb_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>bch_lte_bch_viterbi_vfvb_0</source_block_id><sink_block_id>bch_lte_crc_check_vbvb_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_lte_bch_viterbi_vfvb_0</source_block_id><sink_block_id>bch_lte_crc_check_vbvb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_lte_bch_viterbi_vfvb_0</source_block_id><sink_block_id>bch_lte_crc_check_vbvb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_lte_subblock_deinterleaver_vfvf_0_0</source_block_id><sink_block_id>bch_blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_lte_subblock_deinterleaver_vfvf_0</source_block_id><sink_block_id>bch_blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_blocks_interleave_0</source_block_id><sink_block_id>bch_blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_blocks_vector_to_stream_0_0</source_block_id><sink_block_id>bch_blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>bch_blocks_vector_to_stream_0_1</source_block_id><sink_block_id>bch_blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>bch_blocks_vector_to_stream_0</source_block_id><sink_block_id>bch_blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_lte_subblock_deinterleaver_vfvf_0_1</source_block_id><sink_block_id>bch_blocks_vector_to_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_blocks_stream_to_streams_0</source_block_id><sink_block_id>bch_lte_subblock_deinterleaver_vfvf_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_blocks_stream_to_streams_0</source_block_id><sink_block_id>bch_lte_subblock_deinterleaver_vfvf_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_blocks_stream_to_streams_0</source_block_id><sink_block_id>bch_lte_subblock_deinterleaver_vfvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bch_lte_crc_check_vbvb_0_0</source_block_id><sink_block_id>bch_lte_bch_crc_check_ant_chooser_bb_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
